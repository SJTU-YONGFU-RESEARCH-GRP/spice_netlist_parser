* Random SPICE Netlist
* Generated with 10000 devices
* Device types: M, R, C, V
* Naming: mixed
* Format: mixed
V1a 0 1 DC 13.3                          ; V device
R1b 0 1 5.1M                             ; R device
R1c 1 0 350                              ; R device
R1d 1 0 4.1M                             ; R device
C1e 1 0 3n                               ; C device
C1f 1 0 4.8u                             ; C device
R1g 1 0 6.2M                             ; R device
R1h 0 1 4.2M                             ; R device
R1i 0 1 40k                              ; R device
C1j 0 1 2.8m                             ; C device
C1k 0 1 223p                             ; C device
M1l 3 0 2 1 NMOS L=0.70u W=13.3u         ; M device
M1m 1 2 3 0 NMOS L=0.13u W=54.7u         ; M device
C1n 3 1 16n                              ; C device
R1o 3 1 91k                              ; R device
M1p 2 1 3 0 PMOS L=0.50u W=59.2u AD=46.09p AS=72.27p PD=149.7u PS=154.4u ; M device
R1q 3 2 302                              ; R device
R1r 1 2 3.1M                             ; R device
R1s 1 3 3.3M                             ; R device
C1t 1 2 253p                             ; C device
R1u 0 1 55k                              ; R device
C1v 2 3 212p                             ; C device
M1w 1 2 3 0 NMOS L=0.25u W=59.0u AD=67.28p AS=40.44p PD=229.3u PS=205.4u ; M device
C1x 2 1 9.1m                             ; C device
M1y 1 3 2 0 PMOS L=0.18u W=40.1u         ; M device
M1z 2 1 0 3 NMOS L=0.35u W=31.9u         ; M device
M2a 2 0 1 3 PMOS L=0.10u W=27.0u AD=31.82p AS=52.12p PD=84.6u PS=63.6u ; M device
C2b 2 3 270p                             ; C device
M2c 0 3 2 1 NMOS L=0.50u W=51.3u
+ AD=20.29p AS=74.84p PD=152.8u PS=184.3u ; M device
M2d 2 3 1 0 NMOS L=0.70u W=77.0u         ; M device
M2e 0 1 2 3 NMOS L=0.25u W=3.4u          ; M device
R2f 0 3 863                              ; R device
C2g 3 1 15n                              ; C device
C2h 3 1 8.1m                             ; C device
R2i 2 0 81k                              ; R device
R2j 1 0 987                              ; R device
R2k 1 3 479                              ; R device
M2l 0 3 2 1 PMOS L=0.13u W=41.7u
+ AD=52.06p AS=73.69p PD=137.0u PS=165.7u ; M device
C2m 2 3 2.1u                             ; C device
R2n 2 0 27k                              ; R device
C2o 2 1 2.3u                             ; C device
C2p 2 0 60p                              ; C device
M2q 1 3 2 0 PMOS L=0.10u W=4.3u          ; M device
C2r 0 2 7.1u                             ; C device
M2s 0 1 3 2 PMOS L=0.18u W=19.3u AD=19.04p AS=26.60p PD=54.5u PS=40.7u ; M device
M2t 1 2 0 3 PMOS L=1.00u W=38.4u         ; M device
R2u 2 3 0.7M                             ; R device
C2v 1 0 5.7m                             ; C device
M2w 3 2 1 0 NMOS L=0.13u W=13.9u         ; M device
C2x 1 0 377p                             ; C device
R2y 1 0 0.3M                             ; R device
C2z 0 1 0.3u                             ; C device
R3a 1 2 580                              ; R device
R3b 1 0 896                              ; R device
M3c 0 1 3 2 PMOS L=0.10u W=57.1u         ; M device
C3d 2 3 4.6u                             ; C device
C3e 2 0 0.7m                             ; C device
M3f 1 3 2 0 NMOS L=0.50u W=57.2u
+ AD=26.71p AS=42.01p PD=181.0u PS=141.2u ; M device
M3g 1 2 0 3 NMOS L=0.70u W=18.5u AD=2.67p AS=8.56p PD=37.1u PS=62.1u ; M device
C3h 2 1 980p                             ; C device
C3i 2 0 841p                             ; C device
C3j 3 1 2.2m                             ; C device
C3k 0 3 8.2m                             ; C device
R3l 1 3 1.5M                             ; R device
R3m 1 3 404                              ; R device
M3n 0 1 2 3 PMOS L=0.25u W=1.5u          ; M device
R3o 3 2 99k                              ; R device
R3p 0 2 245                              ; R device
R3q 0 3 6.5M                             ; R device
R3r 3 0 0.1M                             ; R device
C3s 0 1 18n                              ; C device
M3t 3 1 2 0 PMOS L=0.10u W=71.0u         ; M device
M3u 1 3 0 2 PMOS L=0.35u W=2.7u
+ AD=2.23p AS=5.17p PD=7.4u PS=7.3u ; M device
M3v 2 3 1 0 NMOS L=0.10u W=48.6u AD=21.22p AS=89.22p PD=175.0u PS=177.2u ; M device
C3w 0 2 11n                              ; C device
M3x 2 0 3 1 PMOS L=0.50u W=80.9u
+ AD=49.09p AS=109.80p PD=192.9u PS=205.8u ; M device
R3y 2 3 792                              ; R device
M3z 3 2 0 1 PMOS L=0.10u W=63.7u         ; M device
R4a 0 3 523                              ; R device
R4b 2 0 8.0M                             ; R device
R4c 3 0 10k                              ; R device
C4d 2 0 7n                               ; C device
R4e 1 3 686                              ; R device
C4f 2 0 608p                             ; C device
M4g 1 2 3 0 NMOS L=0.25u W=62.0u         ; M device
C4h 3 1 954p                             ; C device
R4i 0 2 845                              ; R device
R4j 2 3 15k                              ; R device
M4k 3 0 1 2 PMOS L=0.18u W=41.6u
+ AD=13.65p AS=47.23p PD=122.6u PS=139.8u ; M device
R4l 2 1 63k                              ; R device
R4m 0 2 63k                              ; R device
M4n 3 2 1 0 NMOS L=0.50u W=45.5u         ; M device
C4o 2 3 2.1u                             ; C device
M4p 1 2 0 3 NMOS L=1.00u W=24.5u AD=4.56p AS=15.41p PD=49.1u PS=55.2u ; M device
R4q 0 2 22k                              ; R device
R4r 0 3 6.2M                             ; R device
R4s 3 2 56k                              ; R device
C4t 3 0 503p                             ; C device
R4u 2 3 62k                              ; R device
C4v 0 3 2.5u                             ; C device
R4w 2 1 234                              ; R device
R4x 0 3 4.0M                             ; R device
C4y 1 3 11n                              ; C device
C4z 3 2 0.7u                             ; C device
M5a 0 2 1 3 NMOS L=0.50u W=70.0u AD=23.60p AS=53.17p PD=181.4u PS=140.1u ; M device
C5b 3 2 584p                             ; C device
C5c 0 2 561p                             ; C device
C5d 1 2 9.8u                             ; C device
M5e 1 0 3 2 NMOS L=0.70u W=4.1u AD=3.27p AS=2.28p PD=13.8u PS=12.0u ; M device
M5f 3 0 2 1 PMOS L=0.10u W=43.8u         ; M device
R5g 1 3 98k                              ; R device
C5h 2 3 1.7m                             ; C device
M5i 2 0 1 3 NMOS L=0.70u W=62.5u         ; M device
C5j 0 2 67n                              ; C device
C5k 0 3 1.1m                             ; C device
R5l 1 0 92k                              ; R device
M5m 1 0 2 3 PMOS L=0.35u W=43.8u         ; M device
M5n 3 0 1 2 NMOS L=0.18u W=38.8u AD=29.81p AS=66.11p PD=135.4u PS=155.2u ; M device
C5o 3 2 2.8u                             ; C device
M5p 1 0 2 3 PMOS L=0.35u W=32.3u
+ AD=10.15p AS=58.20p PD=106.4u PS=113.3u ; M device
C5q 3 2 3.4u                             ; C device
C5r 3 0 2.4u                             ; C device
C5s 1 2 820p                             ; C device
C5t 2 0 608p                             ; C device
R5u 2 1 723                              ; R device
C5v 0 1 5.7m                             ; C device
R5w 2 3 7k                               ; R device
C5x 2 3 811p                             ; C device
R5y 1 0 840                              ; R device
R5z 2 0 4k                               ; R device
M6a 2 1 0 3 PMOS L=0.18u W=16.2u         ; M device
C6b 0 2 1.1u                             ; C device
C6c 3 2 7.8m                             ; C device
M6d 2 1 0 3 NMOS L=0.13u W=74.5u         ; M device
R6e 2 1 663                              ; R device
C6f 2 0 64n                              ; C device
C6g 0 3 52n                              ; C device
C6h 1 2 151p                             ; C device
C6i 3 2 6.4u                             ; C device
C6j 1 2 0.4u                             ; C device
R6k 3 1 878                              ; R device
M6l 0 3 2 1 PMOS L=0.10u W=51.5u         ; M device
R6m 1 0 2.6M                             ; R device
M6n 2 3 0 1 NMOS L=0.10u W=17.3u         ; M device
M6o 2 3 0 1 NMOS L=0.10u W=27.8u         ; M device
C6p 3 1 0.2m                             ; C device
R6q 2 0 4.6M                             ; R device
C6r 0 2 6.3m                             ; C device
R6s 2 3 61k                              ; R device
R6t 1 3 8.4M                             ; R device
R6u 2 1 3.3M                             ; R device
C6v 0 3 1.9m                             ; C device
C6w 2 1 517p                             ; C device
R6x 2 3 725                              ; R device
M6y 0 3 1 2 PMOS L=1.00u W=43.6u         ; M device
R6z 2 1 83k                              ; R device
C7a 2 3 297p                             ; C device
C7b 0 2 3.7u                             ; C device
C7c 3 1 1.0u                             ; C device
M7d 3 2 1 0 PMOS L=0.50u W=37.4u
+ AD=50.77p AS=72.83p PD=80.4u PS=104.6u ; M device
M7e 0 1 3 2 NMOS L=0.50u W=79.6u         ; M device
C7f 0 1 93n                              ; C device
C7g 1 2 68n                              ; C device
R7h 0 2 225                              ; R device
C7i 0 1 2.2u                             ; C device
M7j 0 2 1 3 PMOS L=0.10u W=59.3u         ; M device
M7k 2 1 3 0 PMOS L=0.25u W=79.7u AD=88.45p AS=132.99p PD=240.1u PS=221.7u ; M device
M7l 0 1 3 2 NMOS L=0.10u W=71.1u
+ AD=19.63p AS=65.92p PD=167.5u PS=264.2u ; M device
M7m 3 2 1 0 NMOS L=1.00u W=90.2u AD=78.16p AS=95.66p PD=198.5u PS=298.6u ; M device
C7n 1 2 6.3m                             ; C device
R7o 1 2 0.2M                             ; R device
R7p 1 0 80k                              ; R device
C7q 1 3 1.4m                             ; C device
M7r 1 0 2 3 PMOS L=0.25u W=62.5u         ; M device
C7s 2 3 506p                             ; C device
M7t 2 0 1 3 NMOS L=0.25u W=47.9u
+ AD=55.75p AS=90.28p PD=153.0u PS=96.4u ; M device
R7u 0 3 8k                               ; R device
M7v 0 1 3 2 PMOS L=0.35u W=64.2u         ; M device
C7w 3 2 205p                             ; C device
R7x 3 1 54k                              ; R device
C7y 0 3 4.6u                             ; C device
C7z 1 2 35p                              ; C device
C8a 1 2 64n                              ; C device
C8b 2 1 730p                             ; C device
R8c 3 1 3.2M                             ; R device
C8d 0 3 6.6m                             ; C device
M8e 0 3 2 1 NMOS L=0.13u W=58.8u
+ AD=42.69p AS=88.07p PD=209.0u PS=209.3u ; M device
R8f 1 3 819                              ; R device
M8g 3 2 1 0 PMOS L=0.18u W=41.6u         ; M device
M8h 0 1 2 3 NMOS L=0.70u W=9.6u AD=8.22p AS=18.51p PD=21.1u PS=25.9u ; M device
R8i 3 0 7.9M                             ; R device
R8j 1 2 535                              ; R device
M8k 1 3 0 2 NMOS L=0.25u W=8.4u          ; M device
C8l 0 2 189p                             ; C device
R8m 0 1 32k                              ; R device
R8n 2 1 5.9M                             ; R device
R8o 3 1 347                              ; R device
R8p 3 0 553                              ; R device
R8q 0 3 41k                              ; R device
M8r 3 2 0 1 PMOS L=0.35u W=27.3u AD=22.87p AS=21.08p PD=105.2u PS=98.0u ; M device
R8s 0 1 61                               ; R device
R8t 0 1 3.9M                             ; R device
R8u 2 1 85k                              ; R device
R8v 0 3 69k                              ; R device
C8w 0 2 59n                              ; C device
C8x 1 3 4.4u                             ; C device
M8y 2 3 1 0 NMOS L=0.70u W=12.8u
+ AD=20.99p AS=23.49p PD=35.2u PS=46.9u ; M device
R8z 3 0 9.9M                             ; R device
R9a 3 0 50k                              ; R device
M9b 1 3 2 0 PMOS L=0.13u W=27.7u
+ AD=28.76p AS=27.24p PD=75.2u PS=70.6u ; M device
R9c 1 0 88k                              ; R device
R9d 0 1 44k                              ; R device
C9e 2 1 0.8u                             ; C device
M9f 0 2 1 3 PMOS L=0.70u W=17.2u         ; M device
R9g 3 2 7.4M                             ; R device
R9h 3 0 26k                              ; R device
M9i 3 1 2 0 PMOS L=0.70u W=35.6u
+ AD=49.00p AS=31.25p PD=92.8u PS=115.5u ; M device
C9j 2 1 2.2m                             ; C device
C9k 0 1 614p                             ; C device
M9l 0 3 2 1 PMOS L=0.50u W=52.9u         ; M device
R9m 0 3 35k                              ; R device
M9n 3 0 2 1 PMOS L=0.10u W=99.7u         ; M device
C9o 3 0 3.3u                             ; C device
R9p 3 0 220                              ; R device
R9q 3 1 5.5M                             ; R device
R9r 1 3 45k                              ; R device
M9s 0 1 3 2 NMOS L=1.00u W=39.7u         ; M device
C9t 1 3 950p                             ; C device
M9u 0 2 3 1 PMOS L=0.18u W=47.4u
+ AD=51.06p AS=11.25p PD=120.9u PS=135.8u ; M device
C9v 0 1 66n                              ; C device
R9w 3 0 0.9M                             ; R device
C9x 1 0 435p                             ; C device
R9y 0 3 68                               ; R device
M9z 1 3 0 2 PMOS L=0.10u W=16.5u         ; M device
C10a 0 2 17n                             ; C device
C10b 2 0 225p                            ; C device
M10c 3 0 1 2 PMOS L=0.10u W=40.1u
+ AD=21.72p AS=51.45p PD=95.0u PS=89.4u ; M device
M10d 1 3 2 0 PMOS L=1.00u W=43.2u AD=4.60p AS=69.88p PD=99.0u PS=153.1u ; M device
C10e 3 0 6.1m                            ; C device
M10f 3 1 2 0 NMOS L=0.25u W=83.6u AD=51.22p AS=24.01p PD=217.2u PS=294.2u ; M device
R10g 3 0 464                             ; R device
M10h 2 0 3 1 NMOS L=0.10u W=54.5u
+ AD=68.82p AS=59.80p PD=160.8u PS=139.3u ; M device
M10i 0 2 3 1 NMOS L=0.70u W=81.7u
+ AD=138.16p AS=118.31p PD=298.6u PS=239.0u ; M device
M10j 1 0 3 2 NMOS L=0.50u W=26.8u        ; M device
R10k 2 0 599                             ; R device
R10l 2 3 7.6M                            ; R device
C10m 2 0 0.5u                            ; C device
C10n 2 1 722p                            ; C device
R10o 1 2 79k                             ; R device
C10p 1 2 986p                            ; C device
M10q 2 0 1 3 NMOS L=0.10u W=66.1u        ; M device
C10r 1 2 27n                             ; C device
C10s 3 0 8.3m                            ; C device
R10t 0 1 1k                              ; R device
R10u 2 0 74k                             ; R device
C10v 1 3 29n                             ; C device
C10w 0 2 4.8u                            ; C device
M10x 2 1 3 0 NMOS L=0.50u W=15.2u        ; M device
M10y 1 3 0 2 NMOS L=0.35u W=8.0u         ; M device
C10z 3 1 496p                            ; C device
M11a 2 3 1 0 PMOS L=0.70u W=62.9u AD=29.30p AS=12.66p PD=130.5u PS=144.4u ; M device
M11b 3 0 2 1 PMOS L=0.50u W=70.3u        ; M device
C11c 0 2 62n                             ; C device
C11d 0 1 5.8m                            ; C device
M11e 2 3 1 0 PMOS L=0.10u W=4.3u AD=1.49p AS=7.77p PD=10.5u PS=15.0u ; M device
C11f 0 3 6.3u                            ; C device
R11g 3 2 91k                             ; R device
M11h 1 2 3 0 PMOS L=0.25u W=32.4u
+ AD=11.24p AS=34.25p PD=81.6u PS=72.0u ; M device
C11i 3 2 9.1m                            ; C device
M11j 1 2 3 0 NMOS L=0.50u W=47.4u        ; M device
C11k 0 1 4.8u                            ; C device
R11l 0 2 55k                             ; R device
M11m 3 1 0 2 PMOS L=0.13u W=83.1u
+ AD=79.74p AS=90.50p PD=324.3u PS=301.5u ; M device
M11n 1 3 2 0 PMOS L=0.13u W=7.8u         ; M device
M11o 0 1 2 3 NMOS L=0.35u W=75.7u AD=34.01p AS=26.79p PD=252.0u PS=221.3u ; M device
M11p 0 1 2 3 PMOS L=0.25u W=85.4u
+ AD=68.54p AS=93.66p PD=312.7u PS=301.8u ; M device
C11q 2 1 725p                            ; C device
M11r 3 2 1 0 PMOS L=0.25u W=52.6u        ; M device
R11s 1 3 6.5M                            ; R device
R11t 1 0 10.0M                           ; R device
C11u 3 2 2.6m                            ; C device
M11v 0 3 2 1 PMOS L=0.25u W=90.7u AD=144.62p AS=32.17p PD=278.7u PS=219.2u ; M device
C11w 2 3 95n                             ; C device
R11x 1 3 33k                             ; R device
R11y 0 3 49                              ; R device
R11z 3 2 314                             ; R device
M12a 2 0 1 3 NMOS L=0.35u W=2.8u
+ AD=1.81p AS=2.56p PD=7.7u PS=6.3u ; M device
R12b 1 2 5.6M                            ; R device
C12c 2 3 9.1u                            ; C device
R12d 3 0 8.8M                            ; R device
C12e 1 2 3.7m                            ; C device
M12f 1 0 3 2 NMOS L=0.13u W=28.2u        ; M device
R12g 1 2 8.0M                            ; R device
M12h 2 1 0 3 PMOS L=0.10u W=77.1u        ; M device
R12i 2 1 640                             ; R device
M12j 1 2 0 3 NMOS L=0.18u W=69.3u        ; M device
R12k 2 3 69k                             ; R device
M12l 1 2 3 0 PMOS L=0.50u W=54.0u        ; M device
M12m 2 0 3 1 PMOS L=0.70u W=49.7u        ; M device
M12n 3 2 0 1 NMOS L=0.25u W=13.7u        ; M device
R12o 1 3 8.9M                            ; R device
C12p 3 1 37n                             ; C device
C12q 0 3 108p                            ; C device
M12r 3 1 0 2 PMOS L=0.13u W=76.9u        ; M device
M12s 0 1 3 2 PMOS L=1.00u W=31.5u        ; M device
C12t 3 0 3.6u                            ; C device
R12u 1 2 936                             ; R device
C12v 2 3 26p                             ; C device
M12w 3 1 0 2 NMOS L=0.18u W=29.6u        ; M device
C12x 3 0 873p                            ; C device
R12y 1 3 363                             ; R device
M12z 3 2 0 1 PMOS L=0.25u W=40.6u        ; M device
R13a 2 3 45k                             ; R device
C13b 2 3 22n                             ; C device
C13c 2 1 180p                            ; C device
M13d 2 1 3 0 NMOS L=1.00u W=86.5u
+ AD=25.29p AS=35.37p PD=336.8u PS=179.7u ; M device
C13e 0 3 907p                            ; C device
C13f 0 1 523p                            ; C device
C13g 3 1 0.5u                            ; C device
M13h 3 1 2 0 PMOS L=0.25u W=38.9u        ; M device
M13i 0 3 2 1 NMOS L=0.25u W=12.4u        ; M device
M13j 2 0 3 1 NMOS L=0.13u W=4.5u
+ AD=4.09p AS=8.28p PD=15.3u PS=11.3u ; M device
C13k 0 2 350p                            ; C device
M13l 2 3 1 0 NMOS L=0.13u W=44.3u        ; M device
R13m 1 0 88k                             ; R device
C13n 1 0 32n                             ; C device
M13o 0 3 1 2 PMOS L=0.18u W=86.2u        ; M device
M13p 0 3 1 2 PMOS L=0.13u W=93.6u AD=92.58p AS=39.84p PD=211.7u PS=233.5u ; M device
C13q 0 2 1.3m                            ; C device
C13r 2 1 5.0m                            ; C device
R13s 1 2 530                             ; R device
C13t 0 3 1.5u                            ; C device
R13u 2 1 1.7M                            ; R device
C13v 1 0 78n                             ; C device
C13w 2 0 0.9u                            ; C device
C13x 3 1 8.6m                            ; C device
M13y 0 1 2 3 PMOS L=0.18u W=52.5u AD=95.13p AS=11.88p PD=171.8u PS=146.6u ; M device
C13z 1 2 799p                            ; C device
R14a 2 1 285                             ; R device
M14b 1 2 3 0 NMOS L=0.50u W=18.5u        ; M device
R14c 1 3 2k                              ; R device
C14d 2 3 0.6u                            ; C device
M14e 0 1 3 2 PMOS L=0.70u W=51.2u AD=12.33p AS=53.70p PD=145.8u PS=116.7u ; M device
C14f 2 1 513p                            ; C device
M14g 1 0 3 2 NMOS L=0.70u W=6.0u AD=9.92p AS=3.63p PD=12.0u PS=15.3u ; M device
M14h 0 2 1 3 NMOS L=0.25u W=8.3u
+ AD=15.90p AS=11.72p PD=25.8u PS=21.4u ; M device
M14i 0 1 2 3 NMOS L=0.13u W=44.6u        ; M device
C14j 0 1 397p                            ; C device
M14k 3 1 0 2 NMOS L=0.10u W=93.9u        ; M device
C14l 1 0 458p                            ; C device
M14m 2 3 0 1 PMOS L=0.70u W=65.5u
+ AD=122.59p AS=38.43p PD=190.6u PS=141.5u ; M device
M14n 0 3 2 1 PMOS L=0.35u W=1.3u         ; M device
R14o 2 1 4.9M                            ; R device
M14p 3 0 2 1 PMOS L=0.35u W=92.7u
+ AD=105.20p AS=106.76p PD=308.7u PS=269.4u ; M device
R14q 2 1 34k                             ; R device
C14r 2 1 9.4u                            ; C device
M14s 2 3 0 1 NMOS L=0.18u W=97.1u        ; M device
R14t 3 0 324                             ; R device
M14u 2 1 0 3 NMOS L=0.25u W=77.5u        ; M device
C14v 3 1 0.9m                            ; C device
M14w 1 2 3 0 NMOS L=0.70u W=62.8u
+ AD=71.11p AS=125.38p PD=138.2u PS=145.4u ; M device
M14x 3 1 2 0 PMOS L=1.00u W=65.8u        ; M device
C14y 1 0 8.2u                            ; C device
M14z 1 2 3 0 PMOS L=0.18u W=54.7u AD=108.07p AS=83.81p PD=127.4u PS=135.2u ; M device
M15a 1 2 0 3 NMOS L=0.10u W=47.8u AD=30.92p AS=53.22p PD=115.4u PS=149.4u ; M device
M15b 0 1 2 3 NMOS L=0.25u W=76.9u        ; M device
C15c 2 1 8.3u                            ; C device
M15d 2 0 1 3 PMOS L=0.13u W=15.7u        ; M device
R15e 0 1 274                             ; R device
M15f 3 0 1 2 NMOS L=0.70u W=95.1u        ; M device
R15g 0 1 8.2M                            ; R device
M15h 3 0 2 1 NMOS L=1.00u W=52.7u        ; M device
R15i 1 0 459                             ; R device
R15j 1 3 8.1M                            ; R device
M15k 1 2 3 0 NMOS L=0.70u W=31.7u        ; M device
R15l 3 1 84k                             ; R device
M15m 2 0 3 1 NMOS L=0.10u W=22.9u AD=14.45p AS=30.40p PD=67.8u PS=87.9u ; M device
R15n 3 1 8k                              ; R device
R15o 2 1 49k                             ; R device
M15p 0 2 3 1 PMOS L=1.00u W=89.1u AD=116.58p AS=141.56p PD=217.4u PS=353.4u ; M device
M15q 2 0 1 3 NMOS L=0.50u W=77.3u
+ AD=95.43p AS=45.07p PD=295.5u PS=244.7u ; M device
M15r 2 1 3 0 NMOS L=0.25u W=33.0u AD=40.73p AS=29.14p PD=67.8u PS=103.8u ; M device
R15s 3 1 50k                             ; R device
M15t 3 2 1 0 PMOS L=0.35u W=56.4u AD=33.33p AS=59.99p PD=174.2u PS=134.8u ; M device
M15u 0 1 2 3 NMOS L=0.13u W=16.1u        ; M device
R15v 0 2 501                             ; R device
M15w 1 3 0 2 NMOS L=1.00u W=92.6u        ; M device
R15x 1 0 9.3M                            ; R device
R15y 3 1 42k                             ; R device
C15z 2 0 625p                            ; C device
M16a 0 1 3 2 NMOS L=1.00u W=95.7u AD=165.00p AS=71.86p PD=363.5u PS=227.7u ; M device
C16b 0 3 8.2m                            ; C device
R16c 3 0 172                             ; R device
M16d 0 1 3 2 NMOS L=0.25u W=5.6u AD=5.85p AS=7.17p PD=13.9u PS=14.9u ; M device
R16e 1 2 8.6M                            ; R device
M16f 0 1 2 3 NMOS L=1.00u W=64.8u AD=82.60p AS=101.86p PD=227.3u PS=218.9u ; M device
R16g 0 1 78k                             ; R device
M16h 1 0 3 2 NMOS L=0.18u W=51.2u        ; M device
M16i 3 2 1 0 NMOS L=0.35u W=64.9u        ; M device
R16j 1 3 1.2M                            ; R device
C16k 1 3 4.2u                            ; C device
R16l 1 2 846                             ; R device
M16m 2 1 0 3 PMOS L=1.00u W=1.2u AD=1.52p AS=2.00p PD=2.5u PS=4.2u ; M device
C16n 3 0 9.4m                            ; C device
R16o 3 2 431                             ; R device
C16p 1 3 547p                            ; C device
M16q 1 0 3 2 NMOS L=0.25u W=21.2u AD=12.01p AS=15.86p PD=83.9u PS=58.0u ; M device
C16r 1 2 43n                             ; C device
R16s 1 0 4.8M                            ; R device
M16t 2 0 3 1 NMOS L=1.00u W=81.0u
+ AD=38.30p AS=125.06p PD=201.4u PS=258.6u ; M device
C16u 1 0 751p                            ; C device
M16v 3 2 0 1 PMOS L=0.70u W=3.5u         ; M device
M16w 2 3 0 1 PMOS L=0.35u W=94.6u        ; M device
R16x 2 0 1.4M                            ; R device
C16y 3 1 39n                             ; C device
C16z 3 0 14n                             ; C device
R17a 0 1 213                             ; R device
M17b 0 2 1 3 PMOS L=0.18u W=99.6u AD=136.77p AS=15.57p PD=203.2u PS=276.6u ; M device
R17c 0 2 66k                             ; R device
R17d 1 0 136                             ; R device
M17e 3 2 0 1 NMOS L=0.10u W=10.6u        ; M device
M17f 1 2 0 3 NMOS L=0.18u W=5.9u
+ AD=8.55p AS=7.24p PD=17.3u PS=21.6u ; M device
C17g 3 0 9.4m                            ; C device
R17h 0 1 526                             ; R device
R17i 2 3 63k                             ; R device
R17j 0 2 635                             ; R device
M17k 3 2 1 0 NMOS L=0.70u W=65.1u AD=29.57p AS=61.08p PD=152.3u PS=146.2u ; M device
R17l 3 2 20k                             ; R device
M17m 2 0 1 3 PMOS L=0.70u W=60.4u        ; M device
C17n 2 1 92n                             ; C device
M17o 1 0 3 2 PMOS L=0.70u W=12.5u
+ AD=7.56p AS=13.17p PD=31.1u PS=29.7u ; M device
M17p 3 2 0 1 PMOS L=0.35u W=80.6u AD=100.02p AS=39.40p PD=277.7u PS=239.9u ; M device
C17q 1 0 121p                            ; C device
R17r 0 3 152                             ; R device
C17s 3 1 807p                            ; C device
M17t 3 1 0 2 NMOS L=0.10u W=48.4u        ; M device
C17u 1 3 1.8u                            ; C device
R17v 1 0 0.6M                            ; R device
R17w 2 1 774                             ; R device
C17x 0 1 9.4m                            ; C device
R17y 1 0 2.3M                            ; R device
R17z 1 2 281                             ; R device
R18a 2 1 731                             ; R device
M18b 3 0 1 2 PMOS L=1.00u W=20.5u        ; M device
M18c 3 1 2 0 NMOS L=0.18u W=98.9u AD=173.58p AS=49.45p PD=252.2u PS=219.6u ; M device
R18d 1 0 444                             ; R device
R18e 2 3 5k                              ; R device
R18f 2 3 8.6M                            ; R device
R18g 1 0 381                             ; R device
R18h 1 0 236                             ; R device
C18i 3 0 34n                             ; C device
M18j 0 3 2 1 NMOS L=0.13u W=0.8u AD=1.24p AS=0.81p PD=3.0u PS=2.8u ; M device
R18k 1 3 50k                             ; R device
C18l 1 3 0.8u                            ; C device
R18m 1 2 937                             ; R device
C18n 2 0 2.4m                            ; C device
R18o 3 0 50k                             ; R device
R18p 3 2 6.4M                            ; R device
R18q 0 1 5.3M                            ; R device
C18r 2 3 3.0u                            ; C device
M18s 1 2 3 0 PMOS L=0.25u W=59.7u        ; M device
M18t 1 0 2 3 NMOS L=0.13u W=15.7u AD=3.98p AS=7.10p PD=37.2u PS=33.3u ; M device
R18u 1 0 781                             ; R device
R18v 2 0 3.8M                            ; R device
M18w 2 3 0 1 PMOS L=0.10u W=68.1u
+ AD=20.69p AS=132.17p PD=265.8u PS=169.3u ; M device
R18x 3 2 9k                              ; R device
R18y 1 3 10.0M                           ; R device
C18z 1 0 1.7u                            ; C device
R19a 3 0 45k                             ; R device
C19b 0 2 559p                            ; C device
R19c 0 2 314                             ; R device
M19d 1 3 2 0 PMOS L=0.18u W=83.9u        ; M device
M19e 1 2 3 0 NMOS L=0.18u W=41.0u AD=74.68p AS=58.27p PD=130.4u PS=112.0u ; M device
C19f 1 2 94n                             ; C device
R19g 2 3 7.7M                            ; R device
C19h 3 2 8.3u                            ; C device
C19i 0 1 381p                            ; C device
C19j 0 3 939p                            ; C device
M19k 0 1 3 2 PMOS L=0.18u W=33.4u
+ AD=65.51p AS=16.37p PD=97.5u PS=122.9u ; M device
R19l 0 1 252                             ; R device
R19m 2 1 38k                             ; R device
M19n 1 2 0 3 PMOS L=0.70u W=46.0u        ; M device
M19o 3 1 2 0 NMOS L=0.50u W=17.7u AD=27.85p AS=31.03p PD=40.2u PS=65.8u ; M device
C19p 1 2 7.4m                            ; C device
M19q 1 0 2 3 NMOS L=0.25u W=68.8u        ; M device
M19r 0 3 2 1 NMOS L=0.13u W=60.9u        ; M device
R19s 2 0 0.6M                            ; R device
C19t 1 2 43n                             ; C device
C19u 2 3 6.6m                            ; C device
R19v 0 2 925                             ; R device
C19w 3 2 6.8m                            ; C device
M19x 3 2 1 0 NMOS L=0.10u W=37.0u AD=53.54p AS=20.10p PD=93.2u PS=94.5u ; M device
R19y 0 1 7.0M                            ; R device
M19z 3 0 2 1 PMOS L=0.70u W=92.1u        ; M device
M20a 2 3 1 0 PMOS L=0.10u W=98.4u
+ AD=152.49p AS=133.72p PD=254.4u PS=355.5u ; M device
R20b 3 0 17k                             ; R device
C20c 2 1 1.8u                            ; C device
M20d 1 2 3 0 NMOS L=0.70u W=72.7u        ; M device
R20e 0 1 0.2M                            ; R device
C20f 3 1 0.7m                            ; C device
M20g 1 0 2 3 NMOS L=0.35u W=73.8u AD=65.74p AS=34.67p PD=273.4u PS=254.7u ; M device
M20h 3 0 2 1 NMOS L=1.00u W=50.9u AD=10.96p AS=8.63p PD=157.5u PS=115.8u ; M device
M20i 0 1 3 2 PMOS L=0.25u W=36.9u AD=36.30p AS=28.19p PD=143.8u PS=119.1u ; M device
R20j 2 0 506                             ; R device
M20k 2 3 1 0 PMOS L=0.70u W=21.9u        ; M device
R20l 0 3 8.8M                            ; R device
R20m 0 3 72k                             ; R device
C20n 3 1 4.8u                            ; C device
R20o 0 3 14k                             ; R device
M20p 3 2 0 1 PMOS L=0.10u W=59.4u AD=71.54p AS=57.16p PD=148.2u PS=201.1u ; M device
C20q 0 2 670p                            ; C device
C20r 2 0 5.1m                            ; C device
R20s 2 3 39k                             ; R device
R20t 1 0 7.4M                            ; R device
M20u 0 1 2 3 NMOS L=0.13u W=62.3u        ; M device
C20v 0 3 90n                             ; C device
C20w 2 3 0.4u                            ; C device
R20x 0 3 9.7M                            ; R device
R20y 1 2 804                             ; R device
R20z 3 0 3.0M                            ; R device
M21a 0 1 2 3 NMOS L=0.50u W=0.9u         ; M device
M21b 3 2 1 0 PMOS L=0.35u W=1.7u         ; M device
R21c 3 0 7.3M                            ; R device
M21d 1 0 2 3 PMOS L=0.35u W=16.6u
+ AD=2.22p AS=19.88p PD=44.2u PS=35.5u ; M device
R21e 2 0 9.0M                            ; R device
C21f 1 2 898p                            ; C device
R21g 1 3 83k                             ; R device
M21h 3 2 1 0 PMOS L=0.10u W=73.2u        ; M device
M21i 0 2 3 1 PMOS L=0.13u W=43.8u        ; M device
C21j 2 0 34n                             ; C device
C21k 1 2 76p                             ; C device
R21l 0 2 902                             ; R device
R21m 2 1 18k                             ; R device
R21n 1 3 3.5M                            ; R device
M21o 3 1 2 0 PMOS L=0.13u W=23.1u
+ AD=27.25p AS=4.42p PD=77.3u PS=54.0u ; M device
C21p 3 1 59n                             ; C device
R21q 2 0 9.9M                            ; R device
C21r 1 2 42n                             ; C device
C21s 2 1 7.7m                            ; C device
C21t 3 1 3.9u                            ; C device
R21u 1 2 24                              ; R device
M21v 3 1 0 2 NMOS L=0.70u W=38.0u AD=29.98p AS=30.30p PD=128.7u PS=134.4u ; M device
R21w 0 2 58k                             ; R device
R21x 1 2 6.8M                            ; R device
M21y 0 3 1 2 PMOS L=0.10u W=93.9u AD=55.79p AS=99.37p PD=209.7u PS=196.8u ; M device
R21z 1 3 14k                             ; R device
R22a 1 0 837                             ; R device
M22b 2 0 3 1 NMOS L=0.50u W=41.6u        ; M device
M22c 0 2 1 3 PMOS L=0.25u W=16.4u
+ AD=18.00p AS=19.69p PD=43.9u PS=55.7u ; M device
C22d 3 1 293p                            ; C device
M22e 0 3 1 2 NMOS L=0.10u W=16.8u        ; M device
M22f 2 1 0 3 NMOS L=0.25u W=93.2u        ; M device
M22g 3 1 0 2 NMOS L=0.18u W=88.3u        ; M device
M22h 1 0 2 3 PMOS L=0.10u W=45.1u        ; M device
M22i 3 1 0 2 PMOS L=0.18u W=58.1u        ; M device
R22j 1 0 7.9M                            ; R device
M22k 0 2 3 1 PMOS L=0.10u W=82.6u
+ AD=15.76p AS=134.42p PD=203.3u PS=235.5u ; M device
C22l 0 3 240p                            ; C device
C22m 0 1 64n                             ; C device
C22n 1 3 59n                             ; C device
R22o 2 3 26k                             ; R device
C22p 1 2 4.1u                            ; C device
M22q 2 0 1 3 NMOS L=0.70u W=75.6u AD=80.12p AS=51.44p PD=152.7u PS=277.3u ; M device
M22r 1 0 3 2 PMOS L=0.10u W=70.0u        ; M device
M22s 2 3 1 0 NMOS L=0.10u W=63.1u        ; M device
M22t 2 0 3 1 NMOS L=0.10u W=65.6u
+ AD=71.99p AS=116.45p PD=181.8u PS=229.5u ; M device
R22u 2 3 72k                             ; R device
M22v 2 0 3 1 NMOS L=0.18u W=82.0u        ; M device
M22w 3 1 0 2 NMOS L=0.50u W=20.0u        ; M device
R22x 3 0 425                             ; R device
C22y 0 1 18n                             ; C device
C22z 1 0 217p                            ; C device
M23a 2 1 3 0 PMOS L=0.35u W=16.3u AD=18.66p AS=18.50p PD=60.6u PS=35.9u ; M device
C23b 0 3 52p                             ; C device
C23c 1 0 513p                            ; C device
C23d 1 2 80n                             ; C device
C23e 0 1 8.9m                            ; C device
C23f 3 1 6.4m                            ; C device
M23g 3 1 0 2 PMOS L=0.50u W=21.2u
+ AD=38.55p AS=4.90p PD=71.1u PS=55.0u ; M device
C23h 1 3 6.7u                            ; C device
C23i 2 3 7.8m                            ; C device
M23j 2 0 1 3 NMOS L=0.13u W=57.7u        ; M device
C23k 2 3 3.0m                            ; C device
M23l 0 1 3 2 PMOS L=0.25u W=74.3u AD=20.62p AS=53.31p PD=288.0u PS=183.9u ; M device
C23m 2 3 3.1u                            ; C device
R23n 2 0 386                             ; R device
M23o 0 3 2 1 PMOS L=1.00u W=20.3u
+ AD=36.23p AS=15.31p PD=71.3u PS=52.6u ; M device
R23p 3 2 1.4M                            ; R device
M23q 1 2 3 0 PMOS L=0.35u W=38.8u        ; M device
C23r 0 3 714p                            ; C device
C23s 3 0 4.0m                            ; C device
R23t 1 0 994                             ; R device
M23u 1 0 2 3 PMOS L=0.70u W=89.8u        ; M device
C23v 2 1 15p                             ; C device
C23w 3 1 5.9u                            ; C device
R23x 3 0 535                             ; R device
M23y 3 1 2 0 NMOS L=0.50u W=91.0u        ; M device
C23z 3 1 148p                            ; C device
R24a 1 0 3.5M                            ; R device
M24b 2 0 3 1 NMOS L=0.13u W=67.7u        ; M device
C24c 0 3 0.7u                            ; C device
C24d 2 1 1.6m                            ; C device
R24e 1 3 590                             ; R device
R24f 3 1 57k                             ; R device
C24g 1 0 9.9u                            ; C device
R24h 3 1 964                             ; R device
R24i 3 0 86k                             ; R device
C24j 2 3 828p                            ; C device
M24k 2 1 0 3 PMOS L=0.70u W=14.1u
+ AD=19.21p AS=24.27p PD=41.5u PS=38.8u ; M device
C24l 3 1 17n                             ; C device
R24m 0 2 588                             ; R device
C24n 0 1 5.2m                            ; C device
R24o 2 1 883                             ; R device
C24p 2 3 124p                            ; C device
M24q 1 3 0 2 PMOS L=0.50u W=36.4u        ; M device
C24r 0 3 8.6u                            ; C device
C24s 1 2 529p                            ; C device
R24t 3 0 34k                             ; R device
R24u 1 0 979                             ; R device
R24v 0 2 7.7M                            ; R device
C24w 3 1 3.3u                            ; C device
R24x 1 0 32k                             ; R device
R24y 3 0 28k                             ; R device
R24z 1 3 794                             ; R device
R25a 2 0 269                             ; R device
M25b 2 1 0 3 NMOS L=0.70u W=26.8u AD=26.92p AS=36.21p PD=55.4u PS=82.7u ; M device
M25c 3 0 2 1 PMOS L=1.00u W=40.1u AD=43.91p AS=7.78p PD=152.9u PS=97.1u ; M device
M25d 1 3 2 0 NMOS L=1.00u W=27.6u        ; M device
M25e 3 1 2 0 PMOS L=0.13u W=85.5u        ; M device
C25f 3 2 205p                            ; C device
M25g 1 3 2 0 PMOS L=0.10u W=8.3u         ; M device
C25h 3 0 1.6u                            ; C device
M25i 1 2 0 3 NMOS L=0.18u W=87.7u        ; M device
M25j 3 1 2 0 NMOS L=0.70u W=1.5u
+ AD=3.01p AS=0.27p PD=5.1u PS=4.0u ; M device
M25k 2 3 0 1 NMOS L=0.35u W=40.8u
+ AD=15.46p AS=75.68p PD=95.4u PS=121.8u ; M device
M25l 3 2 1 0 NMOS L=0.18u W=83.3u
+ AD=65.69p AS=68.76p PD=283.4u PS=220.4u ; M device
C25m 1 3 843p                            ; C device
M25n 3 1 2 0 NMOS L=0.35u W=19.9u        ; M device
R25o 2 3 17k                             ; R device
C25p 0 1 41n                             ; C device
R25q 1 3 8.3M                            ; R device
C25r 3 1 150p                            ; C device
M25s 1 3 2 0 PMOS L=0.25u W=65.0u
+ AD=111.11p AS=26.51p PD=218.5u PS=214.9u ; M device
C25t 1 3 8.0m                            ; C device
R25u 1 3 98k                             ; R device
C25v 1 2 347p                            ; C device
R25w 2 0 66k                             ; R device
C25x 0 1 62n                             ; C device
M25y 0 3 1 2 NMOS L=0.35u W=6.0u         ; M device
C25z 1 0 6.4u                            ; C device
C26a 2 3 10n                             ; C device
C26b 2 0 3.4m                            ; C device
R26c 2 3 1.5M                            ; R device
C26d 0 3 7.5m                            ; C device
R26e 2 0 4.9M                            ; R device
M26f 3 0 1 2 NMOS L=0.13u W=91.2u        ; M device
C26g 0 2 6.7m                            ; C device
M26h 1 3 0 2 NMOS L=1.00u W=57.1u        ; M device
M26i 2 3 1 0 NMOS L=1.00u W=53.6u        ; M device
R26j 3 1 5.4M                            ; R device
R26k 3 1 9.9M                            ; R device
R26l 1 2 373                             ; R device
R26m 1 2 6.6M                            ; R device
M26n 0 3 1 2 NMOS L=0.18u W=40.2u        ; M device
C26o 1 2 3.3u                            ; C device
R26p 2 1 1.4M                            ; R device
C26q 3 2 661p                            ; C device
C26r 2 0 59n                             ; C device
R26s 0 3 15k                             ; R device
R26t 0 1 61k                             ; R device
R26u 2 0 8k                              ; R device
R26v 2 1 6.2M                            ; R device
M26w 3 1 2 0 NMOS L=0.25u W=43.2u
+ AD=11.86p AS=48.67p PD=101.7u PS=90.6u ; M device
C26x 0 3 3.8u                            ; C device
C26y 3 1 8.6m                            ; C device
C26z 2 3 46n                             ; C device
C27a 2 3 666p                            ; C device
C27b 2 0 832p                            ; C device
R27c 3 1 79k                             ; R device
R27d 1 3 90k                             ; R device
C27e 1 0 1.8u                            ; C device
R27f 3 2 14k                             ; R device
R27g 0 2 7.2M                            ; R device
M27h 0 3 1 2 PMOS L=0.70u W=95.6u        ; M device
C27i 0 3 18n                             ; C device
M27j 3 2 0 1 PMOS L=1.00u W=5.2u         ; M device
C27k 2 1 0.6u                            ; C device
R27l 0 3 57k                             ; R device
C27m 2 3 940p                            ; C device
M27n 1 0 2 3 NMOS L=0.35u W=3.5u AD=2.93p AS=6.66p PD=12.1u PS=9.7u ; M device
M27o 3 1 2 0 NMOS L=0.25u W=92.9u
+ AD=17.15p AS=30.80p PD=189.9u PS=243.0u ; M device
R27p 0 3 4.7M                            ; R device
R27q 0 3 0.3M                            ; R device
C27r 3 2 435p                            ; C device
C27s 2 0 95n                             ; C device
C27t 1 0 936p                            ; C device
C27u 2 1 4.4m                            ; C device
M27v 2 3 1 0 NMOS L=0.18u W=77.8u AD=75.80p AS=21.97p PD=227.3u PS=283.2u ; M device
M27w 2 0 1 3 NMOS L=1.00u W=32.5u        ; M device
C27x 0 3 0.2m                            ; C device
C27y 0 3 65n                             ; C device
R27z 0 3 21k                             ; R device
R28a 3 2 26k                             ; R device
C28b 3 0 2n                              ; C device
C28c 0 2 1.6u                            ; C device
R28d 2 1 92k                             ; R device
C28e 3 2 75n                             ; C device
M28f 1 0 2 3 PMOS L=0.50u W=0.6u
+ AD=0.83p AS=0.82p PD=1.7u PS=1.4u ; M device
R28g 3 2 8.9M                            ; R device
R28h 3 0 25k                             ; R device
M28i 0 1 3 2 PMOS L=0.35u W=49.8u        ; M device
R28j 1 2 19k                             ; R device
R28k 1 0 4.0M                            ; R device
R28l 3 1 333                             ; R device
R28m 3 1 52k                             ; R device
C28n 1 2 379p                            ; C device
C28o 1 0 8.0m                            ; C device
C28p 2 0 64n                             ; C device
C28q 3 0 4.8m                            ; C device
C28r 3 0 11n                             ; C device
R28s 1 2 37k                             ; R device
M28t 0 2 3 1 NMOS L=0.25u W=29.2u        ; M device
R28u 3 1 9.2M                            ; R device
C28v 2 0 5.6u                            ; C device
C28w 2 3 258p                            ; C device
C28x 2 3 333p                            ; C device
R28y 1 3 93k                             ; R device
C28z 0 2 93n                             ; C device
M29a 3 1 0 2 PMOS L=0.25u W=97.9u
+ AD=35.20p AS=65.86p PD=306.8u PS=326.1u ; M device
R29b 1 0 27                              ; R device
M29c 2 0 3 1 PMOS L=1.00u W=44.5u
+ AD=7.14p AS=71.14p PD=109.1u PS=172.8u ; M device
C29d 2 3 8.6u                            ; C device
R29e 3 0 8.4M                            ; R device
C29f 1 2 3.0m                            ; C device
M29g 3 2 0 1 PMOS L=0.25u W=33.3u        ; M device
R29h 2 0 5.5M                            ; R device
R29i 3 0 4.0M                            ; R device
M29j 2 3 0 1 NMOS L=0.70u W=92.6u        ; M device
R29k 0 1 30k                             ; R device
C29l 0 2 84n                             ; C device
R29m 1 0 4.5M                            ; R device
M29n 2 0 1 3 PMOS L=1.00u W=23.9u
+ AD=30.57p AS=26.39p PD=49.8u PS=80.0u ; M device
C29o 1 3 4.1m                            ; C device
M29p 1 2 3 0 NMOS L=0.35u W=87.2u        ; M device
R29q 1 0 2.6M                            ; R device
C29r 0 2 6.0u                            ; C device
R29s 2 1 56k                             ; R device
R29t 2 3 78k                             ; R device
R29u 3 1 50k                             ; R device
C29v 3 1 50n                             ; C device
R29w 2 0 7.9M                            ; R device
R29x 0 2 3.3M                            ; R device
C29y 1 0 9.7u                            ; C device
R29z 1 3 6.5M                            ; R device
C30a 0 2 82n                             ; C device
R30b 3 0 5.9M                            ; R device
R30c 3 2 54k                             ; R device
M30d 0 3 2 1 NMOS L=0.35u W=16.0u        ; M device
C30e 1 2 5.2m                            ; C device
C30f 2 1 128p                            ; C device
M30g 1 2 3 0 NMOS L=0.50u W=64.9u
+ AD=99.20p AS=51.12p PD=155.2u PS=199.3u ; M device
C30h 3 0 95n                             ; C device
M30i 2 0 3 1 PMOS L=0.10u W=78.9u AD=96.80p AS=132.72p PD=263.2u PS=264.4u ; M device
C30j 2 1 18n                             ; C device
C30k 0 2 410p                            ; C device
C30l 1 2 4n                              ; C device
M30m 0 1 2 3 PMOS L=1.00u W=24.0u        ; M device
C30n 2 1 5.5m                            ; C device
M30o 2 3 1 0 PMOS L=0.13u W=27.7u        ; M device
M30p 1 2 3 0 NMOS L=0.35u W=56.3u        ; M device
C30q 1 0 8n                              ; C device
C30r 1 0 91n                             ; C device
M30s 1 0 2 3 NMOS L=0.25u W=84.8u        ; M device
M30t 3 1 2 0 NMOS L=0.25u W=4.0u         ; M device
R30u 3 1 19k                             ; R device
R30v 1 0 53k                             ; R device
M30w 2 3 1 0 PMOS L=0.70u W=39.1u AD=38.87p AS=8.43p PD=116.6u PS=103.1u ; M device
M30x 1 2 0 3 NMOS L=1.00u W=75.8u
+ AD=49.10p AS=87.22p PD=177.8u PS=169.5u ; M device
C30y 0 2 4.9m                            ; C device
C30z 2 1 119p                            ; C device
R31a 2 0 4.0M                            ; R device
C31b 0 2 15n                             ; C device
C31c 2 3 89n                             ; C device
C31d 1 3 13n                             ; C device
M31e 2 0 3 1 NMOS L=1.00u W=74.2u AD=69.53p AS=32.21p PD=293.2u PS=275.0u ; M device
C31f 0 3 61n                             ; C device
M31g 0 1 3 2 NMOS L=0.10u W=33.2u        ; M device
C31h 0 1 17n                             ; C device
C31i 2 3 8.6m                            ; C device
R31j 3 2 6.5M                            ; R device
R31k 3 2 55k                             ; R device
R31l 1 0 641                             ; R device
R31m 2 0 5.7M                            ; R device
R31n 3 2 93k                             ; R device
M31o 3 2 0 1 NMOS L=1.00u W=40.1u        ; M device
M31p 3 0 2 1 NMOS L=0.50u W=34.0u        ; M device
R31q 3 2 4.4M                            ; R device
C31r 3 0 7.6u                            ; C device
R31s 0 2 292                             ; R device
R31t 0 2 75k                             ; R device
R31u 2 3 680                             ; R device
C31v 3 1 82p                             ; C device
C31w 0 2 7.2u                            ; C device
C31x 1 3 9.8u                            ; C device
C31y 0 1 5.3m                            ; C device
R31z 3 2 9.4M                            ; R device
C32a 1 0 5.1u                            ; C device
M32b 3 1 2 0 PMOS L=0.13u W=16.7u AD=8.40p AS=18.18p PD=41.9u PS=36.3u ; M device
C32c 2 3 9.9u                            ; C device
M32d 2 1 3 0 PMOS L=0.13u W=52.3u
+ AD=6.58p AS=26.23p PD=118.4u PS=137.5u ; M device
M32e 3 2 0 1 NMOS L=0.25u W=30.4u
+ AD=12.43p AS=44.01p PD=100.8u PS=85.4u ; M device
R32f 0 1 695                             ; R device
C32g 2 0 0.5m                            ; C device
C32h 1 3 345p                            ; C device
M32i 3 1 2 0 PMOS L=0.35u W=97.3u        ; M device
C32j 0 1 4.3m                            ; C device
C32k 3 2 457p                            ; C device
M32l 0 1 3 2 NMOS L=0.35u W=21.7u        ; M device
C32m 3 2 1.6u                            ; C device
M32n 0 3 2 1 NMOS L=0.50u W=51.8u        ; M device
R32o 1 0 3.0M                            ; R device
C32p 1 2 305p                            ; C device
R32q 2 3 462                             ; R device
R32r 3 2 43k                             ; R device
C32s 1 2 87n                             ; C device
R32t 0 1 9.1M                            ; R device
R32u 1 2 62k                             ; R device
C32v 3 1 30n                             ; C device
R32w 2 1 55k                             ; R device
R32x 3 2 929                             ; R device
C32y 1 3 15n                             ; C device
R32z 2 1 71k                             ; R device
C33a 0 2 9.1u                            ; C device
M33b 0 1 3 2 NMOS L=0.70u W=95.2u
+ AD=62.21p AS=169.99p PD=224.4u PS=191.9u ; M device
C33c 3 2 8.6u                            ; C device
R33d 2 1 450                             ; R device
M33e 0 2 3 1 NMOS L=0.70u W=19.8u AD=25.33p AS=13.65p PD=77.9u PS=50.7u ; M device
C33f 3 0 6.7m                            ; C device
C33g 1 2 2.2u                            ; C device
R33h 2 1 76k                             ; R device
R33i 3 2 68                              ; R device
M33j 3 1 0 2 PMOS L=0.70u W=45.3u AD=11.58p AS=62.54p PD=174.0u PS=131.4u ; M device
C33k 0 2 4.2m                            ; C device
M33l 1 3 0 2 PMOS L=0.50u W=61.2u        ; M device
R33m 1 3 774                             ; R device
C33n 3 1 41n                             ; C device
R33o 2 1 8.0M                            ; R device
R33p 0 2 26k                             ; R device
M33q 0 1 3 2 PMOS L=0.50u W=75.1u        ; M device
C33r 0 3 262p                            ; C device
R33s 2 3 261                             ; R device
R33t 3 1 36k                             ; R device
C33u 1 2 5.4u                            ; C device
M33v 3 1 0 2 PMOS L=0.10u W=64.1u        ; M device
M33w 3 1 2 0 PMOS L=0.10u W=9.4u AD=14.41p AS=11.94p PD=36.5u PS=33.4u ; M device
M33x 3 0 1 2 NMOS L=0.13u W=57.0u        ; M device
M33y 3 0 1 2 NMOS L=0.18u W=29.2u
+ AD=13.12p AS=53.59p PD=67.2u PS=108.6u ; M device
R33z 0 3 4.6M                            ; R device
R34a 1 2 257                             ; R device
C34b 1 0 6.2m                            ; C device
R34c 3 2 774                             ; R device
R34d 0 3 408                             ; R device
R34e 0 1 7.8M                            ; R device
C34f 2 3 385p                            ; C device
C34g 1 2 812p                            ; C device
R34h 3 2 0.6M                            ; R device
M34i 0 3 2 1 PMOS L=0.13u W=72.7u AD=12.15p AS=65.26p PD=271.0u PS=184.8u ; M device
R34j 0 1 28k                             ; R device
C34k 3 0 960p                            ; C device
C34l 1 3 8.8m                            ; C device
M34m 3 0 1 2 NMOS L=0.13u W=71.9u        ; M device
M34n 3 2 1 0 PMOS L=0.10u W=21.0u        ; M device
R34o 2 1 875                             ; R device
R34p 2 3 8.8M                            ; R device
M34q 0 1 2 3 NMOS L=0.13u W=35.9u        ; M device
M34r 3 0 2 1 PMOS L=0.70u W=55.5u AD=74.71p AS=73.42p PD=111.3u PS=220.3u ; M device
R34s 2 1 79k                             ; R device
C34t 2 3 5.6u                            ; C device
M34u 1 2 3 0 NMOS L=1.00u W=42.4u
+ AD=51.11p AS=41.26p PD=123.9u PS=159.2u ; M device
M34v 1 3 0 2 PMOS L=0.25u W=64.3u        ; M device
M34w 3 1 0 2 NMOS L=0.18u W=68.8u        ; M device
C34x 2 1 656p                            ; C device
M34y 2 0 1 3 NMOS L=0.35u W=74.2u        ; M device
R34z 3 2 1.3M                            ; R device
R35a 3 2 67k                             ; R device
C35b 2 3 937p                            ; C device
C35c 2 0 8n                              ; C device
R35d 1 2 414                             ; R device
M35e 0 1 2 3 NMOS L=0.18u W=74.3u
+ AD=12.30p AS=9.31p PD=204.1u PS=210.6u ; M device
M35f 1 0 3 2 NMOS L=0.70u W=60.7u AD=103.34p AS=72.82p PD=237.9u PS=215.8u ; M device
M35g 1 0 3 2 NMOS L=0.35u W=72.2u        ; M device
R35h 2 3 0.8M                            ; R device
R35i 1 2 8.3M                            ; R device
R35j 3 2 4.7M                            ; R device
C35k 3 2 9.0m                            ; C device
R35l 3 1 8.6M                            ; R device
C35m 1 3 0.7m                            ; C device
R35n 0 3 97k                             ; R device
R35o 2 0 77k                             ; R device
R35p 2 3 8.4M                            ; R device
R35q 1 3 942                             ; R device
R35r 1 3 5.9M                            ; R device
M35s 1 3 0 2 PMOS L=0.13u W=49.7u
+ AD=43.51p AS=48.56p PD=127.2u PS=166.1u ; M device
M35t 1 3 0 2 PMOS L=0.50u W=50.7u        ; M device
M35u 2 1 3 0 PMOS L=0.35u W=39.3u
+ AD=16.76p AS=65.70p PD=98.1u PS=136.3u ; M device
M35v 3 2 0 1 PMOS L=0.70u W=82.4u        ; M device
C35w 3 1 37n                             ; C device
C35x 2 3 0.2u                            ; C device
M35y 0 2 3 1 NMOS L=0.35u W=98.3u        ; M device
R35z 0 3 46k                             ; R device
M36a 2 1 3 0 NMOS L=0.50u W=64.0u        ; M device
M36b 2 3 1 0 NMOS L=0.25u W=93.0u
+ AD=27.31p AS=30.77p PD=216.8u PS=370.7u ; M device
C36c 1 3 9.8m                            ; C device
M36d 1 3 0 2 NMOS L=0.35u W=21.5u AD=32.46p AS=28.87p PD=56.4u PS=75.8u ; M device
R36e 0 1 23k                             ; R device
M36f 3 2 1 0 NMOS L=1.00u W=18.5u AD=21.60p AS=9.75p PD=68.9u PS=58.8u ; M device
M36g 2 1 3 0 NMOS L=0.35u W=87.7u        ; M device
M36h 2 3 1 0 PMOS L=0.50u W=24.2u
+ AD=44.88p AS=39.40p PD=75.1u PS=60.6u ; M device
M36i 1 0 2 3 PMOS L=0.50u W=97.3u
+ AD=172.14p AS=153.40p PD=260.2u PS=347.3u ; M device
R36j 1 0 233                             ; R device
C36k 1 0 44n                             ; C device
R36l 2 3 119                             ; R device
C36m 0 3 1.5u                            ; C device
R36n 2 0 1.0M                            ; R device
M36o 0 2 3 1 PMOS L=1.00u W=42.5u AD=20.56p AS=27.48p PD=162.7u PS=154.2u ; M device
C36p 0 1 7.0m                            ; C device
M36q 2 0 1 3 PMOS L=0.25u W=1.2u         ; M device
M36r 1 3 2 0 PMOS L=0.13u W=77.7u        ; M device
M36s 0 3 1 2 PMOS L=0.35u W=63.0u AD=62.98p AS=122.18p PD=167.7u PS=208.9u ; M device
R36t 2 3 1.5M                            ; R device
M36u 0 3 2 1 PMOS L=0.35u W=35.7u
+ AD=68.12p AS=4.16p PD=117.1u PS=96.1u ; M device
M36v 2 0 3 1 PMOS L=0.35u W=70.8u        ; M device
M36w 0 3 1 2 PMOS L=0.70u W=89.7u        ; M device
M36x 1 3 2 0 PMOS L=0.10u W=50.0u        ; M device
M36y 1 2 0 3 NMOS L=0.25u W=63.3u
+ AD=53.95p AS=66.68p PD=252.4u PS=171.0u ; M device
C36z 3 2 1.9u                            ; C device
C37a 0 2 9.7m                            ; C device
C37b 1 3 4.8u                            ; C device
R37c 3 2 5.2M                            ; R device
C37d 2 0 29n                             ; C device
M37e 1 0 3 2 NMOS L=0.10u W=35.3u
+ AD=68.28p AS=30.26p PD=126.8u PS=114.7u ; M device
M37f 1 3 0 2 PMOS L=0.13u W=69.1u
+ AD=48.65p AS=54.91p PD=164.4u PS=151.5u ; M device
M37g 3 0 1 2 NMOS L=0.70u W=60.6u        ; M device
C37h 1 2 407p                            ; C device
M37i 3 0 1 2 NMOS L=0.25u W=70.7u        ; M device
M37j 1 3 2 0 NMOS L=0.50u W=12.4u        ; M device
R37k 1 2 755                             ; R device
M37l 1 2 3 0 PMOS L=0.50u W=91.3u
+ AD=166.96p AS=129.81p PD=330.9u PS=275.3u ; M device
M37m 1 2 3 0 NMOS L=1.00u W=11.4u AD=11.94p AS=5.67p PD=33.5u PS=38.0u ; M device
C37n 2 3 451p                            ; C device
M37o 1 0 3 2 PMOS L=0.10u W=98.6u
+ AD=90.06p AS=62.91p PD=286.0u PS=282.2u ; M device
R37p 0 1 0.2M                            ; R device
M37q 0 1 2 3 NMOS L=0.70u W=43.8u AD=24.57p AS=7.71p PD=104.6u PS=143.7u ; M device
M37r 1 2 0 3 PMOS L=1.00u W=52.0u        ; M device
R37s 3 2 90k                             ; R device
C37t 3 0 30n                             ; C device
R37u 0 3 6.6M                            ; R device
R37v 0 2 53k                             ; R device
M37w 0 3 1 2 PMOS L=0.35u W=78.3u AD=80.93p AS=126.09p PD=269.8u PS=236.8u ; M device
C37x 1 2 650p                            ; C device
C37y 1 0 25n                             ; C device
R37z 1 0 5.2M                            ; R device
C38a 1 3 194p                            ; C device
M38b 3 1 0 2 PMOS L=0.70u W=63.3u AD=87.26p AS=76.33p PD=199.3u PS=222.2u ; M device
M38c 1 0 3 2 PMOS L=0.18u W=92.5u        ; M device
C38d 0 1 267p                            ; C device
C38e 2 1 3.0u                            ; C device
R38f 0 1 562                             ; R device
C38g 0 2 5.6u                            ; C device
C38h 3 0 4.6u                            ; C device
C38i 1 2 1.8m                            ; C device
R38j 0 1 362                             ; R device
R38k 0 3 91k                             ; R device
R38l 2 3 19                              ; R device
M38m 3 2 0 1 NMOS L=0.70u W=34.3u        ; M device
M38n 1 2 3 0 NMOS L=0.25u W=53.8u        ; M device
M38o 1 3 2 0 PMOS L=0.13u W=82.2u AD=95.24p AS=22.21p PD=297.7u PS=319.4u ; M device
R38p 0 3 9.5M                            ; R device
R38q 3 0 3.0M                            ; R device
R38r 2 1 349                             ; R device
R38s 0 2 33k                             ; R device
C38t 2 0 41n                             ; C device
M38u 2 3 1 0 PMOS L=0.70u W=88.1u        ; M device
M38v 1 2 3 0 NMOS L=0.25u W=40.2u        ; M device
C38w 0 3 950p                            ; C device
C38x 3 1 22n                             ; C device
M38y 3 2 1 0 NMOS L=0.10u W=21.6u AD=30.43p AS=42.30p PD=56.7u PS=68.8u ; M device
R38z 2 3 386                             ; R device
C39a 2 3 4n                              ; C device
C39b 3 1 344p                            ; C device
C39c 3 2 6.4m                            ; C device
R39d 0 2 67k                             ; R device
C39e 3 2 605p                            ; C device
C39f 3 1 6.1m                            ; C device
M39g 0 1 2 3 PMOS L=0.25u W=3.3u AD=0.41p AS=2.01p PD=11.8u PS=7.3u ; M device
R39h 1 0 13k                             ; R device
M39i 1 3 0 2 PMOS L=0.70u W=82.8u AD=67.47p AS=50.08p PD=328.7u PS=295.2u ; M device
C39j 1 3 49p                             ; C device
M39k 1 0 2 3 PMOS L=0.18u W=5.6u
+ AD=6.61p AS=7.05p PD=14.1u PS=18.8u ; M device
M39l 1 3 2 0 NMOS L=0.25u W=51.4u AD=84.36p AS=63.20p PD=104.7u PS=130.2u ; M device
C39m 3 1 986p                            ; C device
M39n 2 3 0 1 NMOS L=0.13u W=18.6u        ; M device
R39o 1 3 4.0M                            ; R device
M39p 1 0 3 2 NMOS L=0.35u W=42.9u        ; M device
M39q 1 0 2 3 PMOS L=1.00u W=16.4u        ; M device
C39r 0 1 152p                            ; C device
C39s 2 1 3.0u                            ; C device
C39t 3 1 5.2m                            ; C device
M39u 3 0 1 2 NMOS L=0.70u W=5.7u AD=3.95p AS=7.34p PD=17.1u PS=17.0u ; M device
M39v 3 0 1 2 NMOS L=0.35u W=42.6u AD=65.15p AS=49.63p PD=150.7u PS=124.7u ; M device
C39w 2 3 8.7u                            ; C device
R39x 0 3 10k                             ; R device
M39y 0 3 1 2 NMOS L=0.35u W=8.4u         ; M device
R39z 1 3 9k                              ; R device
R40a 3 2 0.5M                            ; R device
C40b 0 2 7.7u                            ; C device
R40c 0 2 17k                             ; R device
M40d 1 3 2 0 PMOS L=0.13u W=28.1u        ; M device
C40e 3 0 2.0u                            ; C device
R40f 2 1 0.5M                            ; R device
M40g 1 0 2 3 PMOS L=0.35u W=0.6u AD=0.43p AS=1.04p PD=1.5u PS=1.7u ; M device
R40h 1 2 3.6M                            ; R device
R40i 2 0 51k                             ; R device
M40j 1 0 3 2 PMOS L=0.13u W=99.7u        ; M device
M40k 1 2 3 0 NMOS L=0.50u W=91.8u AD=120.79p AS=17.38p PD=271.5u PS=204.5u ; M device
M40l 2 1 0 3 PMOS L=0.13u W=8.5u         ; M device
C40m 2 3 75n                             ; C device
M40n 3 0 1 2 PMOS L=0.35u W=34.0u
+ AD=14.06p AS=25.25p PD=119.5u PS=106.9u ; M device
C40o 3 1 58n                             ; C device
M40p 2 0 1 3 NMOS L=0.70u W=12.7u        ; M device
C40q 1 3 7n                              ; C device
C40r 0 1 633p                            ; C device
C40s 0 2 411p                            ; C device
M40t 3 1 0 2 PMOS L=0.13u W=91.8u
+ AD=81.33p AS=109.19p PD=222.7u PS=228.6u ; M device
M40u 3 2 1 0 PMOS L=0.18u W=50.2u
+ AD=75.28p AS=34.72p PD=172.6u PS=134.3u ; M device
C40v 0 2 5.8m                            ; C device
R40w 1 0 266                             ; R device
R40x 2 3 632                             ; R device
R40y 3 0 592                             ; R device
R40z 2 1 10.0M                           ; R device
C41a 1 2 87n                             ; C device
M41b 0 3 2 1 NMOS L=0.10u W=21.5u        ; M device
R41c 1 2 780                             ; R device
C41d 3 0 91p                             ; C device
R41e 0 3 34                              ; R device
R41f 3 0 87k                             ; R device
C41g 3 1 31n                             ; C device
C41h 1 2 2.9u                            ; C device
R41i 1 3 8                               ; R device
R41j 0 3 64k                             ; R device
C41k 2 1 83n                             ; C device
C41l 1 2 8.2u                            ; C device
C41m 1 2 9.7u                            ; C device
R41n 0 1 345                             ; R device
C41o 1 0 99n                             ; C device
M41p 2 0 3 1 NMOS L=0.70u W=7.6u         ; M device
M41q 2 1 0 3 NMOS L=0.35u W=23.0u        ; M device
R41r 3 1 1.6M                            ; R device
R41s 0 3 5.0M                            ; R device
M41t 0 3 2 1 PMOS L=0.50u W=91.5u
+ AD=75.87p AS=160.47p PD=233.2u PS=226.2u ; M device
M41u 2 3 0 1 PMOS L=0.35u W=30.1u AD=44.54p AS=58.78p PD=62.6u PS=115.1u ; M device
R41v 2 0 439                             ; R device
C41w 3 2 41n                             ; C device
R41x 2 1 55k                             ; R device
C41y 2 1 972p                            ; C device
C41z 3 1 9.2m                            ; C device
C42a 3 0 7.1u                            ; C device
C42b 3 0 9.0u                            ; C device
C42c 2 0 903p                            ; C device
R42d 0 3 45k                             ; R device
M42e 0 2 1 3 NMOS L=0.10u W=18.3u        ; M device
R42f 2 1 4.1M                            ; R device
M42g 1 3 2 0 NMOS L=0.18u W=2.5u
+ AD=0.34p AS=3.89p PD=8.4u PS=5.7u ; M device
R42h 0 1 38k                             ; R device
C42i 2 3 4.5u                            ; C device
C42j 2 1 9n                              ; C device
C42k 2 3 664p                            ; C device
M42l 2 1 0 3 PMOS L=0.50u W=93.5u        ; M device
R42m 1 2 3.1M                            ; R device
C42n 3 2 7.3m                            ; C device
R42o 2 0 24k                             ; R device
M42p 2 1 0 3 NMOS L=0.50u W=10.0u        ; M device
C42q 2 1 3.4u                            ; C device
C42r 1 2 9.7m                            ; C device
C42s 2 0 89n                             ; C device
R42t 0 2 4.2M                            ; R device
C42u 3 1 1.9m                            ; C device
R42v 1 3 8.7M                            ; R device
R42w 0 1 619                             ; R device
C42x 0 1 2.9m                            ; C device
R42y 0 3 36k                             ; R device
M42z 1 0 2 3 PMOS L=0.35u W=56.4u AD=44.41p AS=23.62p PD=221.1u PS=192.8u ; M device
C43a 2 3 6.5u                            ; C device
M43b 3 1 2 0 PMOS L=0.18u W=21.8u        ; M device
R43c 3 0 931                             ; R device
C43d 1 0 6.3u                            ; C device
C43e 1 0 1.6u                            ; C device
M43f 3 2 0 1 PMOS L=1.00u W=24.8u
+ AD=40.19p AS=30.41p PD=56.9u PS=83.9u ; M device
M43g 0 2 3 1 NMOS L=0.50u W=60.9u        ; M device
M43h 2 1 0 3 PMOS L=0.18u W=77.8u AD=80.04p AS=98.69p PD=173.6u PS=268.3u ; M device
M43i 1 2 3 0 PMOS L=1.00u W=6.9u         ; M device
M43j 1 0 2 3 NMOS L=0.25u W=57.5u AD=107.34p AS=62.47p PD=137.0u PS=130.9u ; M device
R43k 3 2 0.5M                            ; R device
M43l 3 1 2 0 NMOS L=0.10u W=26.6u        ; M device
C43m 3 1 8.2m                            ; C device
R43n 2 1 3.7M                            ; R device
C43o 1 3 49n                             ; C device
M43p 0 3 2 1 NMOS L=0.18u W=89.2u AD=135.96p AS=100.24p PD=278.9u PS=222.8u ; M device
R43q 0 3 275                             ; R device
R43r 1 0 764                             ; R device
C43s 1 0 783p                            ; C device
R43t 1 3 772                             ; R device
M43u 3 0 2 1 NMOS L=0.35u W=55.7u        ; M device
C43v 1 0 2.5u                            ; C device
C43w 3 0 4.8u                            ; C device
R43x 3 1 44k                             ; R device
R43y 2 0 77                              ; R device
R43z 0 1 473                             ; R device
C44a 1 2 82p                             ; C device
R44b 2 3 75k                             ; R device
R44c 1 3 5.6M                            ; R device
R44d 1 0 9k                              ; R device
M44e 0 1 3 2 PMOS L=0.10u W=69.1u        ; M device
R44f 0 3 34k                             ; R device
M44g 1 2 0 3 NMOS L=0.25u W=34.8u        ; M device
M44h 2 1 3 0 PMOS L=0.18u W=21.7u        ; M device
R44i 1 3 222                             ; R device
M44j 1 2 0 3 PMOS L=0.18u W=88.7u        ; M device
R44k 1 3 890                             ; R device
C44l 1 2 4n                              ; C device
R44m 1 0 3.9M                            ; R device
C44n 2 0 54n                             ; C device
C44o 2 0 30n                             ; C device
C44p 0 1 71n                             ; C device
R44q 1 3 146                             ; R device
M44r 0 2 1 3 PMOS L=0.35u W=43.5u AD=73.95p AS=22.13p PD=90.8u PS=118.5u ; M device
R44s 3 1 7.9M                            ; R device
R44t 1 3 66k                             ; R device
C44u 1 2 7.9m                            ; C device
C44v 2 3 8.3m                            ; C device
M44w 2 3 1 0 PMOS L=0.35u W=80.3u        ; M device
R44x 1 0 738                             ; R device
C44y 2 1 60n                             ; C device
R44z 1 3 45k                             ; R device
R45a 1 2 6.1M                            ; R device
M45b 2 3 1 0 PMOS L=0.25u W=16.1u
+ AD=28.27p AS=21.91p PD=42.9u PS=35.5u ; M device
C45c 1 0 81n                             ; C device
R45d 1 2 56k                             ; R device
R45e 0 2 182                             ; R device
M45f 1 3 2 0 NMOS L=0.70u W=62.0u        ; M device
R45g 3 0 28k                             ; R device
C45h 0 2 409p                            ; C device
R45i 3 0 95k                             ; R device
M45j 0 3 1 2 NMOS L=0.13u W=87.5u        ; M device
R45k 2 3 975                             ; R device
C45l 0 1 0.4u                            ; C device
M45m 2 0 1 3 PMOS L=0.70u W=50.5u AD=81.45p AS=86.01p PD=159.3u PS=173.7u ; M device
M45n 0 1 2 3 PMOS L=0.25u W=44.2u AD=29.48p AS=15.89p PD=129.6u PS=170.2u ; M device
C45o 2 3 94n                             ; C device
C45p 1 2 55n                             ; C device
M45q 0 2 3 1 PMOS L=0.35u W=80.3u
+ AD=36.52p AS=65.11p PD=316.6u PS=306.6u ; M device
R45r 2 3 556                             ; R device
M45s 2 0 1 3 PMOS L=0.10u W=97.1u AD=25.10p AS=148.63p PD=360.2u PS=252.3u ; M device
M45t 0 1 3 2 NMOS L=0.35u W=87.9u        ; M device
C45u 0 3 474p                            ; C device
M45v 3 0 2 1 NMOS L=0.70u W=88.1u AD=19.45p AS=34.24p PD=231.3u PS=294.3u ; M device
M45w 3 2 0 1 NMOS L=0.70u W=75.2u        ; M device
C45x 3 0 847p                            ; C device
M45y 0 2 1 3 PMOS L=0.18u W=85.9u        ; M device
R45z 1 0 1.4M                            ; R device
R46a 0 2 4.1M                            ; R device
M46b 3 1 0 2 PMOS L=0.25u W=42.7u        ; M device
R46c 2 1 1.9M                            ; R device
R46d 2 1 369                             ; R device
C46e 3 2 504p                            ; C device
R46f 3 2 754                             ; R device
C46g 3 0 0.6m                            ; C device
R46h 0 3 3.5M                            ; R device
R46i 0 1 3.0M                            ; R device
R46j 1 2 7.1M                            ; R device
R46k 2 1 79k                             ; R device
R46l 1 2 37k                             ; R device
C46m 1 2 848p                            ; C device
R46n 2 0 668                             ; R device
R46o 3 1 217                             ; R device
M46p 2 0 1 3 NMOS L=1.00u W=75.9u AD=133.11p AS=59.82p PD=282.9u PS=169.9u ; M device
M46q 0 3 2 1 PMOS L=0.25u W=95.7u AD=97.94p AS=146.46p PD=300.1u PS=309.1u ; M device
R46r 1 0 94k                             ; R device
R46s 1 3 4.8M                            ; R device
R46t 2 1 31k                             ; R device
M46u 0 1 3 2 NMOS L=0.18u W=86.5u AD=134.75p AS=130.59p PD=249.0u PS=295.8u ; M device
M46v 1 0 3 2 PMOS L=0.13u W=55.7u AD=105.39p AS=58.33p PD=133.4u PS=206.4u ; M device
M46w 0 3 2 1 PMOS L=0.13u W=72.3u        ; M device
M46x 2 3 0 1 NMOS L=0.13u W=39.7u        ; M device
R46y 2 3 962                             ; R device
M46z 2 0 1 3 NMOS L=0.50u W=95.5u        ; M device
M47a 0 2 1 3 NMOS L=0.13u W=38.2u        ; M device
R47b 0 2 27k                             ; R device
R47c 1 2 68k                             ; R device
M47d 2 3 1 0 PMOS L=0.50u W=91.6u        ; M device
C47e 1 2 68n                             ; C device
M47f 2 1 3 0 PMOS L=0.10u W=95.7u        ; M device
R47g 0 1 6.9M                            ; R device
M47h 3 1 2 0 PMOS L=0.35u W=31.1u AD=60.43p AS=55.63p PD=77.7u PS=101.1u ; M device
M47i 3 1 2 0 PMOS L=0.10u W=78.6u        ; M device
C47j 1 0 88n                             ; C device
R47k 2 0 5.1M                            ; R device
C47l 0 1 5.9u                            ; C device
M47m 3 2 1 0 NMOS L=1.00u W=42.4u        ; M device
C47n 3 1 241p                            ; C device
M47o 3 1 2 0 NMOS L=0.18u W=59.9u
+ AD=35.79p AS=71.35p PD=216.6u PS=232.3u ; M device
R47p 2 0 95k                             ; R device
M47q 2 1 0 3 PMOS L=0.13u W=18.9u
+ AD=34.06p AS=27.59p PD=67.5u PS=46.4u ; M device
R47r 0 2 14k                             ; R device
C47s 2 1 5.5u                            ; C device
M47t 3 0 1 2 NMOS L=0.13u W=99.4u
+ AD=43.48p AS=18.59p PD=233.0u PS=220.4u ; M device
M47u 0 1 2 3 NMOS L=0.25u W=30.4u AD=60.15p AS=47.75p PD=89.6u PS=74.0u ; M device
C47v 1 0 54n                             ; C device
R47w 1 0 0.7M                            ; R device
R47x 2 0 3.1M                            ; R device
C47y 1 0 5.7u                            ; C device
C47z 0 2 1.2u                            ; C device
C48a 0 3 35n                             ; C device
R48b 0 1 18k                             ; R device
C48c 3 0 0.8u                            ; C device
R48d 1 0 90k                             ; R device
M48e 1 3 2 0 NMOS L=0.35u W=19.0u        ; M device
M48f 1 0 3 2 NMOS L=0.25u W=80.6u        ; M device
M48g 3 2 1 0 NMOS L=0.70u W=98.5u
+ AD=68.95p AS=193.55p PD=327.1u PS=385.9u ; M device
C48h 2 0 1.9m                            ; C device
R48i 0 3 98k                             ; R device
C48j 3 2 3.9u                            ; C device
C48k 3 2 94p                             ; C device
C48l 0 2 97n                             ; C device
R48m 2 3 2.1M                            ; R device
M48n 2 0 1 3 NMOS L=0.18u W=29.2u AD=23.79p AS=37.53p PD=59.2u PS=102.9u ; M device
C48o 0 2 7.6u                            ; C device
M48p 1 0 3 2 NMOS L=0.50u W=38.4u
+ AD=53.17p AS=5.17p PD=121.0u PS=146.1u ; M device
C48q 0 3 2.3u                            ; C device
C48r 2 3 4.2u                            ; C device
M48s 3 0 2 1 NMOS L=0.25u W=72.8u        ; M device
C48t 3 2 16n                             ; C device
M48u 1 0 2 3 NMOS L=0.18u W=52.3u
+ AD=71.56p AS=58.00p PD=121.8u PS=159.8u ; M device
R48v 0 1 50k                             ; R device
M48w 3 1 0 2 NMOS L=0.35u W=85.1u
+ AD=99.40p AS=56.79p PD=261.4u PS=181.1u ; M device
M48x 2 1 0 3 PMOS L=0.50u W=85.5u        ; M device
M48y 3 0 2 1 NMOS L=0.70u W=85.9u        ; M device
M48z 2 3 0 1 PMOS L=0.35u W=69.0u        ; M device
M49a 2 1 0 3 NMOS L=1.00u W=68.8u        ; M device
R49b 0 1 8.4M                            ; R device
M49c 2 1 0 3 NMOS L=1.00u W=44.2u
+ AD=65.13p AS=71.57p PD=131.7u PS=123.0u ; M device
C49d 2 3 4n                              ; C device
M49e 1 2 3 0 PMOS L=0.13u W=97.9u        ; M device
R49f 0 3 5.1M                            ; R device
C49g 1 0 83n                             ; C device
M49h 1 3 2 0 NMOS L=1.00u W=77.6u        ; M device
C49i 2 0 40n                             ; C device
R49j 3 0 19                              ; R device
R49k 1 0 26k                             ; R device
R49l 3 1 13k                             ; R device
M49m 0 3 1 2 PMOS L=0.10u W=24.9u AD=34.88p AS=40.82p PD=68.7u PS=51.1u ; M device
R49n 2 3 4.1M                            ; R device
C49o 0 1 2.0m                            ; C device
C49p 2 3 0.9u                            ; C device
R49q 3 2 356                             ; R device
M49r 1 3 2 0 NMOS L=0.18u W=34.4u
+ AD=68.66p AS=16.94p PD=96.9u PS=74.2u ; M device
R49s 1 3 6.0M                            ; R device
C49t 2 0 8.9u                            ; C device
R49u 2 1 223                             ; R device
M49v 0 2 1 3 PMOS L=0.35u W=87.0u AD=150.94p AS=67.64p PD=342.7u PS=221.3u ; M device
M49w 0 2 3 1 NMOS L=0.10u W=71.6u
+ AD=17.25p AS=128.46p PD=208.3u PS=275.0u ; M device
R49x 3 1 9.2M                            ; R device
R49y 3 0 267                             ; R device
C49z 1 3 432p                            ; C device
M50a 2 1 0 3 PMOS L=1.00u W=62.5u        ; M device
C50b 1 0 9.8u                            ; C device
C50c 0 3 34n                             ; C device
R50d 0 2 8.6M                            ; R device
M50e 2 3 0 1 PMOS L=1.00u W=62.3u
+ AD=106.61p AS=21.17p PD=140.8u PS=129.0u ; M device
M50f 1 2 3 0 NMOS L=0.13u W=72.5u
+ AD=136.91p AS=142.21p PD=235.5u PS=246.9u ; M device
C50g 0 1 492p                            ; C device
C50h 2 1 824p                            ; C device
M50i 3 1 0 2 NMOS L=0.10u W=2.5u AD=3.29p AS=0.85p PD=7.2u PS=5.6u ; M device
C50j 1 2 145p                            ; C device
R50k 1 3 5.8M                            ; R device
M50l 3 1 0 2 PMOS L=0.50u W=53.4u        ; M device
C50m 1 3 33n                             ; C device
C50n 2 0 5.9u                            ; C device
M50o 1 3 2 0 PMOS L=0.18u W=56.9u        ; M device
M50p 0 3 2 1 NMOS L=0.70u W=55.5u
+ AD=41.87p AS=82.16p PD=203.7u PS=116.8u ; M device
C50q 0 1 32n                             ; C device
M50r 3 1 2 0 PMOS L=0.70u W=6.2u AD=2.49p AS=6.93p PD=12.6u PS=23.5u ; M device
M50s 1 2 0 3 PMOS L=0.50u W=73.9u        ; M device
R50t 1 2 3.3M                            ; R device
M50u 2 0 3 1 NMOS L=1.00u W=5.2u         ; M device
M50v 2 1 3 0 PMOS L=0.18u W=63.3u AD=29.72p AS=8.17p PD=229.5u PS=245.4u ; M device
R50w 3 1 65k                             ; R device
C50x 3 0 71n                             ; C device
R50y 0 2 2.6M                            ; R device
C50z 2 1 781p                            ; C device
R51a 1 2 555                             ; R device
M51b 2 0 1 3 PMOS L=0.13u W=65.5u
+ AD=108.26p AS=67.34p PD=161.0u PS=192.6u ; M device
R51c 2 1 127                             ; R device
R51d 1 2 7.4M                            ; R device
C51e 2 0 3n                              ; C device
C51f 2 3 50n                             ; C device
R51g 1 0 1.7M                            ; R device
C51h 0 3 132p                            ; C device
M51i 1 2 3 0 NMOS L=0.10u W=85.7u
+ AD=54.62p AS=123.57p PD=174.4u PS=302.5u ; M device
R51j 0 2 10.0M                           ; R device
R51k 2 3 40k                             ; R device
M51l 3 1 0 2 PMOS L=0.25u W=44.6u AD=35.86p AS=17.02p PD=159.1u PS=91.2u ; M device
M51m 1 0 2 3 NMOS L=0.10u W=44.9u        ; M device
R51n 1 0 28k                             ; R device
C51o 1 2 4.3u                            ; C device
R51p 0 2 2k                              ; R device
M51q 1 2 3 0 NMOS L=0.13u W=88.2u        ; M device
C51r 2 0 3.3m                            ; C device
R51s 0 3 1.9M                            ; R device
M51t 3 1 0 2 NMOS L=1.00u W=86.1u        ; M device
R51u 1 3 735                             ; R device
R51v 1 3 130                             ; R device
R51w 0 2 738                             ; R device
M51x 1 0 3 2 PMOS L=0.10u W=89.7u        ; M device
C51y 0 3 97n                             ; C device
R51z 1 2 77k                             ; R device
C52a 0 3 84n                             ; C device
C52b 1 3 6.3u                            ; C device
R52c 1 3 890                             ; R device
R52d 3 0 93k                             ; R device
C52e 3 1 4.4m                            ; C device
M52f 1 3 2 0 NMOS L=0.13u W=97.1u        ; M device
R52g 1 2 67k                             ; R device
R52h 1 0 5.2M                            ; R device
M52i 2 0 1 3 NMOS L=0.25u W=33.2u        ; M device
R52j 1 3 69k                             ; R device
R52k 2 1 94k                             ; R device
R52l 1 3 79k                             ; R device
M52m 0 2 1 3 NMOS L=0.35u W=46.4u        ; M device
M52n 2 0 3 1 PMOS L=0.35u W=70.9u        ; M device
M52o 1 2 0 3 PMOS L=1.00u W=38.7u        ; M device
C52p 2 3 933p                            ; C device
M52q 3 2 0 1 PMOS L=0.13u W=86.7u        ; M device
M52r 3 2 1 0 NMOS L=0.25u W=86.7u AD=101.84p AS=170.12p PD=265.4u PS=296.0u ; M device
R52s 2 1 440                             ; R device
C52t 2 1 732p                            ; C device
C52u 3 0 3.1u                            ; C device
R52v 0 3 0.5M                            ; R device
R52w 2 0 6.5M                            ; R device
R52x 3 0 7.1M                            ; R device
M52y 3 0 2 1 PMOS L=0.35u W=64.9u
+ AD=41.89p AS=23.11p PD=230.9u PS=225.3u ; M device
R52z 1 2 6.1M                            ; R device
M53a 2 1 3 0 PMOS L=1.00u W=81.9u AD=140.25p AS=112.79p PD=317.0u PS=295.9u ; M device
R53b 3 0 17k                             ; R device
R53c 3 2 373                             ; R device
R53d 2 3 5.9M                            ; R device
R53e 2 3 3.2M                            ; R device
M53f 0 2 3 1 PMOS L=0.35u W=41.2u        ; M device
M53g 1 0 3 2 PMOS L=1.00u W=2.7u
+ AD=3.65p AS=3.14p PD=6.7u PS=7.9u ; M device
M53h 2 1 0 3 PMOS L=0.35u W=6.9u         ; M device
C53i 2 3 93n                             ; C device
R53j 1 2 6.9M                            ; R device
C53k 0 2 4.8m                            ; C device
R53l 2 3 32k                             ; R device
C53m 0 1 8.1u                            ; C device
M53n 0 1 2 3 PMOS L=1.00u W=90.2u        ; M device
M53o 2 1 0 3 NMOS L=0.35u W=51.0u        ; M device
R53p 3 0 5k                              ; R device
C53q 1 3 74n                             ; C device
C53r 1 2 9.5m                            ; C device
C53s 3 2 5.2u                            ; C device
R53t 3 1 0.2M                            ; R device
R53u 1 3 9.9M                            ; R device
R53v 1 0 6.2M                            ; R device
M53w 2 0 3 1 PMOS L=0.13u W=12.5u AD=17.22p AS=13.12p PD=29.6u PS=38.9u ; M device
C53x 1 2 59n                             ; C device
M53y 3 1 0 2 PMOS L=0.13u W=10.4u
+ AD=19.84p AS=1.30p PD=26.4u PS=38.1u ; M device
C53z 3 2 29n                             ; C device
R54a 3 2 1k                              ; R device
R54b 1 3 30k                             ; R device
M54c 3 2 1 0 PMOS L=0.10u W=37.0u AD=9.55p AS=29.85p PD=80.5u PS=147.2u ; M device
M54d 2 3 0 1 PMOS L=0.50u W=99.4u        ; M device
R54e 2 1 49k                             ; R device
R54f 1 3 5.5M                            ; R device
R54g 1 3 2.9M                            ; R device
C54h 0 2 9.1m                            ; C device
C54i 2 1 1.2m                            ; C device
C54j 1 0 2n                              ; C device
M54k 2 1 3 0 NMOS L=0.25u W=59.5u        ; M device
C54l 3 2 77n                             ; C device
C54m 1 3 3.1m                            ; C device
C54n 1 0 46n                             ; C device
M54o 1 2 3 0 PMOS L=0.10u W=72.7u        ; M device
C54p 1 2 6.7u                            ; C device
M54q 3 1 0 2 PMOS L=0.25u W=36.6u        ; M device
R54r 3 0 9.7M                            ; R device
C54s 0 3 444p                            ; C device
M54t 2 0 1 3 PMOS L=0.70u W=74.6u        ; M device
C54u 1 3 7.3u                            ; C device
M54v 1 0 3 2 PMOS L=0.70u W=69.9u        ; M device
R54w 0 2 656                             ; R device
C54x 3 2 22n                             ; C device
R54y 0 1 456                             ; R device
R54z 1 0 850                             ; R device
M55a 0 1 2 3 NMOS L=0.50u W=73.5u
+ AD=86.74p AS=137.83p PD=179.1u PS=157.9u ; M device
R55b 3 1 7.5M                            ; R device
C55c 2 0 862p                            ; C device
M55d 1 0 3 2 NMOS L=0.50u W=29.9u AD=44.03p AS=19.83p PD=64.3u PS=111.6u ; M device
R55e 1 3 41k                             ; R device
C55f 3 1 64n                             ; C device
R55g 2 1 84k                             ; R device
R55h 2 0 158                             ; R device
R55i 2 3 1.8M                            ; R device
C55j 0 1 289p                            ; C device
C55k 1 3 1.8u                            ; C device
R55l 3 0 83k                             ; R device
M55m 1 3 2 0 PMOS L=0.70u W=79.6u        ; M device
M55n 3 1 2 0 NMOS L=0.50u W=20.5u
+ AD=16.60p AS=27.92p PD=67.5u PS=73.2u ; M device
R55o 3 1 58k                             ; R device
M55p 2 1 0 3 PMOS L=0.18u W=7.3u         ; M device
M55q 0 2 1 3 NMOS L=0.13u W=7.4u AD=6.30p AS=10.14p PD=20.5u PS=21.6u ; M device
M55r 3 2 1 0 PMOS L=0.50u W=69.4u
+ AD=76.51p AS=134.62p PD=162.3u PS=224.8u ; M device
R55s 2 0 4.4M                            ; R device
C55t 1 2 1.1m                            ; C device
M55u 2 0 3 1 PMOS L=0.25u W=45.5u        ; M device
M55v 2 3 0 1 PMOS L=0.25u W=10.6u        ; M device
M55w 3 1 0 2 NMOS L=0.25u W=96.5u AD=77.56p AS=87.26p PD=282.7u PS=331.4u ; M device
C55x 1 0 55n                             ; C device
M55y 1 2 3 0 NMOS L=0.70u W=22.6u        ; M device
C55z 3 0 9.2m                            ; C device
R56a 0 1 558                             ; R device
M56b 3 0 2 1 NMOS L=0.50u W=34.5u
+ AD=34.52p AS=4.38p PD=71.6u PS=74.0u ; M device
C56c 2 0 216p                            ; C device
R56d 2 1 21k                             ; R device
C56e 0 1 989p                            ; C device
M56f 3 0 1 2 PMOS L=0.50u W=45.5u        ; M device
M56g 0 2 1 3 NMOS L=0.13u W=52.5u        ; M device
R56h 0 1 740                             ; R device
R56i 1 2 7k                              ; R device
M56j 3 1 2 0 PMOS L=1.00u W=0.8u         ; M device
R56k 3 0 27k                             ; R device
R56l 2 0 17k                             ; R device
M56m 1 2 0 3 NMOS L=0.25u W=62.9u
+ AD=112.23p AS=117.85p PD=230.2u PS=242.2u ; M device
R56n 3 0 525                             ; R device
C56o 2 1 6.1u                            ; C device
M56p 0 1 3 2 PMOS L=0.35u W=59.5u        ; M device
R56q 1 0 14k                             ; R device
C56r 1 0 10n                             ; C device
M56s 3 0 2 1 NMOS L=1.00u W=6.2u         ; M device
R56t 3 1 4.8M                            ; R device
C56u 3 2 8.3u                            ; C device
M56v 2 3 1 0 PMOS L=0.70u W=92.1u AD=154.79p AS=94.24p PD=313.4u PS=190.3u ; M device
C56w 1 2 69n                             ; C device
R56x 2 1 702                             ; R device
R56y 0 2 50k                             ; R device
M56z 0 2 1 3 NMOS L=0.25u W=4.4u         ; M device
R57a 1 2 66k                             ; R device
M57b 2 1 3 0 PMOS L=0.10u W=85.8u
+ AD=49.00p AS=103.77p PD=291.8u PS=332.5u ; M device
R57c 0 2 14                              ; R device
C57d 2 1 2.1u                            ; C device
C57e 2 3 0.1u                            ; C device
C57f 2 1 6.2m                            ; C device
M57g 3 2 0 1 NMOS L=0.70u W=3.7u AD=2.54p AS=6.46p PD=9.9u PS=13.3u ; M device
M57h 1 2 3 0 NMOS L=0.50u W=80.1u AD=140.18p AS=60.38p PD=287.8u PS=271.9u ; M device
M57i 1 0 2 3 NMOS L=0.25u W=78.5u
+ AD=116.88p AS=12.86p PD=285.9u PS=265.7u ; M device
R57j 3 0 993                             ; R device
M57k 3 0 1 2 NMOS L=1.00u W=49.7u        ; M device
M57l 0 1 3 2 NMOS L=0.35u W=85.8u        ; M device
C57m 1 2 22n                             ; C device
R57n 0 1 4.4M                            ; R device
M57o 3 1 2 0 NMOS L=0.50u W=9.1u         ; M device
R57p 2 1 29k                             ; R device
M57q 3 1 2 0 PMOS L=1.00u W=89.4u        ; M device
C57r 2 0 8.7m                            ; C device
M57s 2 3 1 0 PMOS L=0.35u W=34.8u        ; M device
M57t 3 1 2 0 PMOS L=0.25u W=46.5u
+ AD=41.31p AS=39.05p PD=161.4u PS=106.9u ; M device
R57u 1 2 3.6M                            ; R device
M57v 2 1 0 3 PMOS L=0.25u W=20.9u
+ AD=16.95p AS=38.92p PD=63.9u PS=51.9u ; M device
R57w 0 3 40k                             ; R device
C57x 0 3 7.0u                            ; C device
R57y 0 3 8.8M                            ; R device
M57z 2 0 3 1 PMOS L=0.25u W=62.9u AD=47.03p AS=72.14p PD=146.1u PS=249.5u ; M device
R58a 2 0 4.9M                            ; R device
C58b 0 1 2.0m                            ; C device
R58c 0 1 262                             ; R device
R58d 0 3 7.1M                            ; R device
M58e 0 1 3 2 NMOS L=1.00u W=76.8u
+ AD=15.50p AS=149.58p PD=155.5u PS=276.5u ; M device
R58f 0 3 43k                             ; R device
M58g 1 3 0 2 PMOS L=0.13u W=3.7u
+ AD=2.87p AS=2.90p PD=14.2u PS=10.6u ; M device
M58h 3 2 0 1 PMOS L=1.00u W=54.7u AD=69.42p AS=19.15p PD=195.6u PS=167.2u ; M device
M58i 1 0 2 3 NMOS L=1.00u W=38.2u        ; M device
M58j 3 2 0 1 PMOS L=0.35u W=15.3u        ; M device
C58k 1 3 0.2m                            ; C device
M58l 2 1 0 3 PMOS L=0.35u W=66.8u AD=74.44p AS=22.97p PD=141.7u PS=210.8u ; M device
C58m 3 1 0.5m                            ; C device
C58n 1 2 3.0u                            ; C device
M58o 2 3 1 0 NMOS L=0.50u W=79.8u
+ AD=16.31p AS=99.08p PD=280.7u PS=177.6u ; M device
R58p 0 3 341                             ; R device
C58q 3 1 257p                            ; C device
R58r 2 3 6k                              ; R device
M58s 2 3 0 1 PMOS L=0.50u W=89.6u        ; M device
R58t 2 0 970                             ; R device
R58u 1 3 3k                              ; R device
C58v 1 0 79n                             ; C device
R58w 1 0 82k                             ; R device
R58x 2 3 3.4M                            ; R device
C58y 3 0 472p                            ; C device
M58z 0 3 2 1 PMOS L=1.00u W=36.4u
+ AD=52.93p AS=53.88p PD=129.9u PS=91.3u ; M device
C59a 0 3 10.0u                           ; C device
R59b 0 1 1.2M                            ; R device
R59c 0 1 974                             ; R device
M59d 0 2 3 1 NMOS L=0.25u W=29.8u
+ AD=32.68p AS=53.00p PD=82.7u PS=64.4u ; M device
R59e 0 1 436                             ; R device
R59f 0 3 665                             ; R device
C59g 0 1 5.5m                            ; C device
R59h 2 1 62                              ; R device
R59i 2 3 66k                             ; R device
R59j 1 2 2.7M                            ; R device
R59k 0 2 5.1M                            ; R device
R59l 2 1 158                             ; R device
R59m 0 2 37k                             ; R device
C59n 0 2 4.3m                            ; C device
C59o 1 0 6.3m                            ; C device
C59p 2 0 7.5m                            ; C device
C59q 2 1 5.8m                            ; C device
C59r 1 0 160p                            ; C device
R59s 3 0 1.3M                            ; R device
C59t 3 2 513p                            ; C device
R59u 1 3 995                             ; R device
M59v 3 1 2 0 NMOS L=1.00u W=14.3u
+ AD=25.54p AS=2.09p PD=42.4u PS=32.8u ; M device
R59w 3 1 406                             ; R device
M59x 0 1 3 2 PMOS L=0.25u W=73.4u        ; M device
C59y 0 3 95n                             ; C device
R59z 1 2 776                             ; R device
R60a 0 2 364                             ; R device
M60b 0 1 2 3 NMOS L=0.25u W=22.4u
+ AD=16.90p AS=9.95p PD=83.2u PS=56.8u ; M device
C60c 1 3 76n                             ; C device
C60d 1 2 625p                            ; C device
R60e 2 0 20k                             ; R device
R60f 3 2 74k                             ; R device
R60g 2 3 1                               ; R device
C60h 3 0 37n                             ; C device
M60i 1 3 2 0 PMOS L=0.18u W=94.1u AD=170.97p AS=62.85p PD=231.3u PS=195.4u ; M device
M60j 0 2 1 3 NMOS L=0.18u W=99.8u        ; M device
M60k 1 2 0 3 PMOS L=0.18u W=59.2u
+ AD=24.42p AS=66.85p PD=204.6u PS=129.6u ; M device
R60l 1 2 733                             ; R device
R60m 3 1 878                             ; R device
R60n 1 2 412                             ; R device
M60o 2 0 1 3 NMOS L=0.13u W=48.7u
+ AD=84.73p AS=24.24p PD=173.5u PS=161.1u ; M device
R60p 3 1 869                             ; R device
C60q 0 1 3.1m                            ; C device
R60r 0 3 983                             ; R device
C60s 1 2 0.5m                            ; C device
M60t 2 3 1 0 PMOS L=0.50u W=81.8u        ; M device
C60u 3 1 792p                            ; C device
R60v 3 2 1.6M                            ; R device
R60w 2 3 261                             ; R device
C60x 0 3 7.2m                            ; C device
R60y 3 2 384                             ; R device
M60z 0 1 2 3 NMOS L=0.70u W=3.4u         ; M device
C61a 2 3 689p                            ; C device
C61b 3 1 3.2m                            ; C device
R61c 1 3 0.3M                            ; R device
R61d 2 1 23k                             ; R device
M61e 3 1 2 0 PMOS L=0.35u W=91.5u        ; M device
R61f 1 0 5.8M                            ; R device
R61g 2 1 419                             ; R device
R61h 1 3 25k                             ; R device
M61i 2 3 1 0 NMOS L=0.25u W=77.0u
+ AD=63.37p AS=148.01p PD=249.9u PS=231.7u ; M device
C61j 3 2 3.7m                            ; C device
C61k 0 1 7.2u                            ; C device
M61l 2 1 3 0 NMOS L=0.25u W=11.3u        ; M device
M61m 3 2 1 0 NMOS L=0.70u W=8.4u AD=6.68p AS=2.12p PD=28.9u PS=18.0u ; M device
C61n 3 2 5.6m                            ; C device
C61o 1 2 5.2u                            ; C device
R61p 2 1 888                             ; R device
M61q 2 1 3 0 NMOS L=0.25u W=63.1u AD=18.07p AS=80.56p PD=248.2u PS=200.0u ; M device
C61r 3 2 79n                             ; C device
M61s 2 0 3 1 NMOS L=0.35u W=56.4u AD=24.29p AS=97.47p PD=177.0u PS=166.6u ; M device
R61t 0 1 3.6M                            ; R device
C61u 2 3 4.3u                            ; C device
C61v 2 3 832p                            ; C device
R61w 3 2 16k                             ; R device
C61x 3 2 2.8u                            ; C device
R61y 2 1 262                             ; R device
R61z 2 1 91k                             ; R device
R62a 3 2 41k                             ; R device
M62b 1 3 2 0 NMOS L=0.18u W=54.0u AD=32.18p AS=69.70p PD=153.1u PS=167.5u ; M device
M62c 1 3 0 2 PMOS L=1.00u W=68.2u        ; M device
R62d 1 3 9k                              ; R device
M62e 0 2 3 1 PMOS L=0.13u W=24.0u        ; M device
M62f 2 1 3 0 PMOS L=1.00u W=29.1u AD=54.65p AS=39.86p PD=94.6u PS=88.9u ; M device
M62g 1 3 0 2 NMOS L=0.25u W=70.6u        ; M device
R62h 0 3 9.0M                            ; R device
R62i 2 0 6.1M                            ; R device
R62j 2 3 2.6M                            ; R device
M62k 3 1 0 2 PMOS L=0.18u W=8.2u         ; M device
C62l 0 3 365p                            ; C device
C62m 0 3 8.0m                            ; C device
M62n 3 1 0 2 NMOS L=0.35u W=73.2u AD=124.21p AS=95.30p PD=274.3u PS=242.4u ; M device
C62o 1 0 8.6u                            ; C device
M62p 2 0 3 1 NMOS L=0.35u W=61.9u
+ AD=17.48p AS=6.89p PD=232.4u PS=205.4u ; M device
C62q 2 0 1.7m                            ; C device
M62r 0 1 3 2 PMOS L=0.50u W=68.1u
+ AD=115.29p AS=90.70p PD=151.9u PS=181.4u ; M device
C62s 2 0 1.5m                            ; C device
C62t 2 3 20n                             ; C device
C62u 3 0 8.6u                            ; C device
M62v 3 1 2 0 NMOS L=1.00u W=64.3u        ; M device
C62w 0 1 145p                            ; C device
M62x 1 2 3 0 PMOS L=0.70u W=1.9u         ; M device
R62y 1 3 61k                             ; R device
R62z 3 1 36k                             ; R device
M63a 1 0 2 3 PMOS L=0.70u W=61.4u AD=9.00p AS=78.95p PD=134.4u PS=136.7u ; M device
M63b 2 3 1 0 PMOS L=0.10u W=89.3u        ; M device
C63c 2 1 9.9u                            ; C device
R63d 0 1 0.3M                            ; R device
M63e 2 3 0 1 NMOS L=0.35u W=6.9u         ; M device
C63f 3 0 3.5u                            ; C device
M63g 3 1 2 0 NMOS L=0.13u W=88.0u
+ AD=52.35p AS=111.39p PD=215.0u PS=204.7u ; M device
M63h 3 0 1 2 NMOS L=0.13u W=58.1u AD=81.66p AS=40.87p PD=173.0u PS=140.0u ; M device
R63i 2 1 89k                             ; R device
M63j 3 0 1 2 NMOS L=0.10u W=83.4u
+ AD=70.97p AS=116.18p PD=272.3u PS=224.8u ; M device
C63k 3 0 879p                            ; C device
R63l 0 1 265                             ; R device
M63m 0 1 2 3 NMOS L=1.00u W=31.5u        ; M device
R63n 3 1 9.6M                            ; R device
R63o 2 1 599                             ; R device
R63p 3 1 22k                             ; R device
R63q 2 1 22k                             ; R device
C63r 2 1 203p                            ; C device
R63s 0 3 5.9M                            ; R device
C63t 0 1 9.4u                            ; C device
M63u 3 2 1 0 PMOS L=1.00u W=94.6u        ; M device
C63v 3 1 3.0m                            ; C device
C63w 3 2 4.9u                            ; C device
C63x 1 2 23n                             ; C device
M63y 0 3 1 2 NMOS L=0.10u W=38.7u        ; M device
M63z 3 2 0 1 NMOS L=0.18u W=93.8u
+ AD=30.78p AS=103.72p PD=337.5u PS=241.0u ; M device
R64a 0 2 7k                              ; R device
C64b 0 2 2n                              ; C device
R64c 1 0 18k                             ; R device
M64d 0 3 2 1 NMOS L=0.25u W=46.7u        ; M device
M64e 2 3 1 0 NMOS L=0.10u W=35.3u AD=30.46p AS=14.67p PD=137.9u PS=97.1u ; M device
R64f 1 2 3.0M                            ; R device
M64g 3 1 0 2 NMOS L=1.00u W=69.9u        ; M device
C64h 2 3 3.5m                            ; C device
C64i 2 0 80n                             ; C device
M64j 0 1 3 2 PMOS L=0.50u W=96.5u AD=120.39p AS=61.26p PD=290.5u PS=290.1u ; M device
C64k 0 2 2.6u                            ; C device
M64l 2 0 1 3 NMOS L=0.10u W=4.8u         ; M device
C64m 3 1 7.4u                            ; C device
R64n 2 3 89k                             ; R device
C64o 0 3 39n                             ; C device
R64p 2 1 56k                             ; R device
R64q 3 1 33k                             ; R device
C64r 0 1 599p                            ; C device
C64s 3 1 574p                            ; C device
M64t 3 1 2 0 NMOS L=0.10u W=81.3u AD=110.93p AS=9.20p PD=204.5u PS=258.5u ; M device
R64u 1 0 5.2M                            ; R device
M64v 1 2 0 3 NMOS L=0.10u W=71.1u AD=63.24p AS=21.38p PD=257.0u PS=283.4u ; M device
M64w 0 1 3 2 NMOS L=0.70u W=6.1u AD=7.33p AS=6.87p PD=16.2u PS=21.1u ; M device
R64x 2 1 6.3M                            ; R device
M64y 0 1 2 3 PMOS L=0.13u W=45.3u AD=51.39p AS=39.53p PD=142.7u PS=158.5u ; M device
C64z 0 2 342p                            ; C device
R65a 2 0 7.5M                            ; R device
M65b 2 0 3 1 PMOS L=0.25u W=65.0u        ; M device
M65c 1 2 0 3 PMOS L=0.13u W=59.7u
+ AD=86.15p AS=100.96p PD=172.8u PS=161.4u ; M device
M65d 2 1 0 3 PMOS L=0.25u W=75.0u AD=140.96p AS=65.80p PD=181.3u PS=259.6u ; M device
M65e 0 1 2 3 PMOS L=0.13u W=83.0u        ; M device
C65f 1 0 2.1u                            ; C device
R65g 3 0 3.5M                            ; R device
R65h 2 3 41                              ; R device
R65i 2 0 3k                              ; R device
R65j 1 3 6.2M                            ; R device
M65k 0 3 2 1 PMOS L=1.00u W=88.6u        ; M device
M65l 2 3 1 0 PMOS L=0.18u W=54.3u AD=94.35p AS=77.93p PD=177.8u PS=118.4u ; M device
C65m 1 3 28n                             ; C device
C65n 3 0 6.9u                            ; C device
C65o 2 1 170p                            ; C device
C65p 0 2 41n                             ; C device
C65q 2 1 216p                            ; C device
C65r 0 1 6.0u                            ; C device
M65s 2 3 1 0 PMOS L=0.35u W=81.0u AD=43.61p AS=153.52p PD=275.7u PS=184.5u ; M device
C65t 3 1 287p                            ; C device
R65u 2 0 6.8M                            ; R device
C65v 2 1 876p                            ; C device
M65w 0 1 3 2 NMOS L=0.70u W=10.7u        ; M device
M65x 0 1 2 3 PMOS L=0.25u W=6.8u AD=7.55p AS=5.81p PD=17.8u PS=22.5u ; M device
M65y 2 1 0 3 PMOS L=0.50u W=73.6u
+ AD=139.48p AS=38.35p PD=260.6u PS=239.4u ; M device
R65z 0 2 183                             ; R device
R66a 3 0 95k                             ; R device
C66b 3 1 80n                             ; C device
M66c 3 0 2 1 NMOS L=1.00u W=85.5u        ; M device
C66d 2 0 1.6m                            ; C device
C66e 3 1 0.5u                            ; C device
C66f 0 3 448p                            ; C device
R66g 0 2 618                             ; R device
R66h 1 3 10k                             ; R device
C66i 1 2 8.7m                            ; C device
M66j 3 2 0 1 NMOS L=0.25u W=39.6u
+ AD=30.49p AS=46.98p PD=85.8u PS=116.0u ; M device
R66k 0 1 15k                             ; R device
R66l 0 2 97k                             ; R device
M66m 0 1 2 3 PMOS L=0.35u W=91.2u AD=79.09p AS=86.85p PD=315.1u PS=280.5u ; M device
M66n 2 3 0 1 PMOS L=1.00u W=61.5u        ; M device
C66o 3 1 33n                             ; C device
C66p 2 3 4.9u                            ; C device
C66q 3 1 495p                            ; C device
M66r 1 3 0 2 NMOS L=0.13u W=15.6u        ; M device
C66s 1 3 7.1u                            ; C device
R66t 3 2 930                             ; R device
R66u 3 0 485                             ; R device
C66v 3 2 98p                             ; C device
C66w 0 1 96n                             ; C device
C66x 0 1 160p                            ; C device
M66y 2 1 0 3 PMOS L=0.25u W=12.5u AD=6.89p AS=17.83p PD=25.7u PS=45.3u ; M device
M66z 0 1 3 2 PMOS L=0.70u W=62.2u        ; M device
R67a 2 0 0.5M                            ; R device
M67b 1 3 0 2 NMOS L=0.70u W=85.2u AD=77.38p AS=144.50p PD=300.6u PS=215.2u ; M device
M67c 1 0 2 3 NMOS L=1.00u W=51.7u        ; M device
R67d 1 2 16k                             ; R device
C67e 2 3 19n                             ; C device
M67f 0 2 1 3 PMOS L=1.00u W=68.9u
+ AD=42.98p AS=68.72p PD=208.4u PS=213.1u ; M device
R67g 2 3 5.8M                            ; R device
C67h 2 0 726p                            ; C device
R67i 2 3 379                             ; R device
C67j 2 1 6.2m                            ; C device
M67k 3 1 0 2 PMOS L=0.18u W=57.8u        ; M device
R67l 2 1 3k                              ; R device
M67m 3 2 1 0 PMOS L=0.25u W=72.5u        ; M device
C67n 0 2 31n                             ; C device
C67o 1 2 5.0m                            ; C device
C67p 2 3 3.8u                            ; C device
R67q 1 3 70k                             ; R device
M67r 3 2 0 1 NMOS L=0.50u W=37.8u        ; M device
R67s 3 1 5.2M                            ; R device
C67t 1 2 93n                             ; C device
R67u 0 3 34k                             ; R device
C67v 1 3 2.2m                            ; C device
M67w 1 3 2 0 NMOS L=0.18u W=55.0u AD=33.72p AS=45.77p PD=178.6u PS=143.0u ; M device
M67x 3 2 0 1 PMOS L=0.25u W=23.2u        ; M device
M67y 1 2 3 0 PMOS L=0.50u W=9.3u
+ AD=12.16p AS=8.23p PD=19.4u PS=27.5u ; M device
R67z 2 0 7.8M                            ; R device
C68a 1 2 8.7u                            ; C device
R68b 3 1 320                             ; R device
M68c 1 0 2 3 NMOS L=0.18u W=32.2u
+ AD=10.85p AS=27.04p PD=80.8u PS=77.1u ; M device
C68d 0 2 7.0m                            ; C device
C68e 2 1 212p                            ; C device
M68f 3 1 2 0 PMOS L=0.18u W=99.9u        ; M device
M68g 1 0 2 3 PMOS L=0.50u W=57.0u        ; M device
C68h 1 3 9.2u                            ; C device
C68i 0 1 5.4m                            ; C device
R68j 0 2 2.4M                            ; R device
M68k 1 3 2 0 PMOS L=0.18u W=52.7u        ; M device
C68l 2 0 30n                             ; C device
R68m 0 1 949                             ; R device
M68n 1 2 0 3 PMOS L=0.50u W=21.3u AD=35.82p AS=40.25p PD=45.3u PS=60.4u ; M device
R68o 2 0 903                             ; R device
C68p 2 3 0.4u                            ; C device
R68q 2 1 688                             ; R device
M68r 0 3 1 2 NMOS L=0.18u W=43.2u        ; M device
R68s 0 1 1.9M                            ; R device
C68t 3 0 33n                             ; C device
C68u 0 2 6.9m                            ; C device
M68v 3 1 0 2 NMOS L=0.25u W=28.7u AD=50.14p AS=3.84p PD=88.3u PS=81.6u ; M device
M68w 0 3 1 2 PMOS L=0.18u W=32.0u AD=30.46p AS=40.71p PD=110.5u PS=111.5u ; M device
C68x 0 3 149p                            ; C device
M68y 2 0 1 3 NMOS L=0.35u W=39.3u AD=40.80p AS=52.72p PD=87.4u PS=109.0u ; M device
C68z 2 0 40n                             ; C device
R69a 2 3 71k                             ; R device
M69b 2 1 0 3 PMOS L=0.50u W=73.9u        ; M device
M69c 0 2 3 1 PMOS L=0.10u W=13.3u
+ AD=11.60p AS=6.27p PD=52.1u PS=37.0u ; M device
R69d 0 3 39k                             ; R device
M69e 3 1 0 2 NMOS L=0.70u W=17.3u        ; M device
M69f 2 0 1 3 NMOS L=0.13u W=10.7u
+ AD=6.80p AS=11.49p PD=39.6u PS=31.3u ; M device
R69g 3 1 7.9M                            ; R device
R69h 0 3 891                             ; R device
M69i 3 1 2 0 NMOS L=0.35u W=5.2u
+ AD=1.68p AS=8.53p PD=15.1u PS=17.8u ; M device
R69j 3 0 29                              ; R device
M69k 3 2 1 0 PMOS L=1.00u W=5.0u
+ AD=9.28p AS=0.61p PD=12.9u PS=17.2u ; M device
C69l 3 2 70n                             ; C device
M69m 3 2 1 0 NMOS L=0.13u W=65.4u        ; M device
M69n 3 2 1 0 PMOS L=0.50u W=10.9u        ; M device
C69o 3 0 0.2u                            ; C device
R69p 1 0 95k                             ; R device
R69q 1 3 599                             ; R device
M69r 3 1 2 0 NMOS L=0.50u W=57.7u        ; M device
M69s 1 2 0 3 PMOS L=0.13u W=22.6u        ; M device
C69t 2 0 88n                             ; C device
M69u 2 1 0 3 NMOS L=0.35u W=97.2u        ; M device
R69v 1 0 46k                             ; R device
R69w 0 1 0.9M                            ; R device
C69x 1 3 5.3u                            ; C device
C69y 0 2 62n                             ; C device
M69z 0 3 2 1 PMOS L=0.70u W=29.1u AD=29.51p AS=55.86p PD=85.8u PS=87.0u ; M device
R70a 1 2 710                             ; R device
C70b 1 2 8.2u                            ; C device
M70c 0 2 3 1 NMOS L=0.10u W=62.1u        ; M device
R70d 0 3 50k                             ; R device
M70e 1 3 0 2 PMOS L=0.50u W=27.1u AD=52.95p AS=48.84p PD=65.8u PS=71.0u ; M device
R70f 1 2 181                             ; R device
M70g 2 1 0 3 PMOS L=0.25u W=77.9u AD=131.85p AS=151.79p PD=167.1u PS=172.3u ; M device
C70h 0 2 94n                             ; C device
C70i 1 0 3.9u                            ; C device
M70j 3 2 1 0 PMOS L=0.25u W=93.6u        ; M device
C70k 1 3 86n                             ; C device
M70l 0 1 2 3 NMOS L=0.13u W=32.8u
+ AD=42.97p AS=26.89p PD=79.6u PS=90.4u ; M device
R70m 3 0 0.2M                            ; R device
M70n 0 2 3 1 PMOS L=0.18u W=31.1u AD=42.28p AS=51.28p PD=73.6u PS=109.5u ; M device
C70o 1 3 579p                            ; C device
R70p 2 0 4.4M                            ; R device
R70q 2 0 5.9M                            ; R device
M70r 3 2 0 1 NMOS L=1.00u W=84.5u        ; M device
C70s 2 3 20n                             ; C device
C70t 0 3 64n                             ; C device
C70u 3 2 613p                            ; C device
C70v 1 2 67n                             ; C device
R70w 2 1 73k                             ; R device
M70x 0 2 1 3 NMOS L=0.25u W=5.2u AD=1.02p AS=2.86p PD=15.0u PS=15.5u ; M device
C70y 0 3 67n                             ; C device
R70z 2 1 4k                              ; R device
C71a 0 3 9.2u                            ; C device
C71b 2 3 40n                             ; C device
R71c 0 1 46k                             ; R device
C71d 0 2 6.5u                            ; C device
M71e 1 2 0 3 PMOS L=0.70u W=84.4u        ; M device
M71f 1 2 0 3 PMOS L=0.50u W=95.2u        ; M device
C71g 2 0 70n                             ; C device
M71h 3 1 2 0 NMOS L=0.35u W=57.3u AD=70.10p AS=90.64p PD=211.5u PS=197.6u ; M device
M71i 1 2 0 3 NMOS L=0.35u W=30.5u        ; M device
M71j 2 3 0 1 PMOS L=0.70u W=0.5u         ; M device
R71k 1 0 9.6M                            ; R device
C71l 2 0 82n                             ; C device
M71m 2 1 3 0 PMOS L=0.50u W=98.3u        ; M device
R71n 3 0 886                             ; R device
M71o 3 1 2 0 PMOS L=0.35u W=87.9u
+ AD=92.62p AS=156.01p PD=208.1u PS=237.1u ; M device
C71p 2 0 798p                            ; C device
M71q 1 3 0 2 NMOS L=0.18u W=5.5u         ; M device
C71r 1 3 0.7m                            ; C device
C71s 3 2 9.9u                            ; C device
C71t 3 0 467p                            ; C device
M71u 1 3 0 2 PMOS L=0.35u W=90.0u
+ AD=58.75p AS=103.18p PD=209.7u PS=326.9u ; M device
R71v 3 1 40k                             ; R device
C71w 2 3 538p                            ; C device
R71x 2 0 6.2M                            ; R device
C71y 0 2 642p                            ; C device
M71z 2 0 3 1 PMOS L=0.13u W=96.3u AD=175.22p AS=144.36p PD=208.4u PS=324.4u ; M device
C72a 0 2 6.3m                            ; C device
C72b 1 0 112p                            ; C device
C72c 3 1 203p                            ; C device
C72d 3 1 65n                             ; C device
C72e 3 0 675p                            ; C device
C72f 0 1 7.3u                            ; C device
M72g 0 1 2 3 NMOS L=0.25u W=59.6u
+ AD=44.93p AS=109.76p PD=124.0u PS=185.1u ; M device
R72h 1 2 5.5M                            ; R device
C72i 2 3 6.4m                            ; C device
M72j 3 2 1 0 NMOS L=0.50u W=66.0u AD=97.19p AS=26.49p PD=167.8u PS=144.1u ; M device
C72k 3 1 27n                             ; C device
M72l 3 1 2 0 NMOS L=0.13u W=59.3u
+ AD=39.84p AS=45.28p PD=159.4u PS=200.7u ; M device
C72m 1 0 752p                            ; C device
M72n 2 3 0 1 NMOS L=0.10u W=81.8u
+ AD=130.41p AS=87.44p PD=166.1u PS=263.1u ; M device
M72o 2 0 1 3 NMOS L=1.00u W=67.2u
+ AD=111.60p AS=33.42p PD=206.4u PS=235.7u ; M device
M72p 2 3 1 0 PMOS L=1.00u W=48.9u        ; M device
M72q 3 0 2 1 NMOS L=0.70u W=64.0u
+ AD=22.53p AS=17.04p PD=163.4u PS=251.8u ; M device
R72r 0 2 4.3M                            ; R device
C72s 0 2 0.4m                            ; C device
M72t 2 1 3 0 PMOS L=0.25u W=22.2u        ; M device
M72u 3 0 2 1 PMOS L=1.00u W=30.1u        ; M device
C72v 3 2 865p                            ; C device
M72w 2 1 0 3 NMOS L=0.25u W=93.1u
+ AD=14.49p AS=52.70p PD=290.1u PS=195.5u ; M device
M72x 0 2 3 1 NMOS L=0.10u W=59.2u        ; M device
C72y 1 2 69n                             ; C device
M72z 0 3 2 1 NMOS L=0.13u W=94.2u        ; M device
R73a 2 1 263                             ; R device
M73b 3 1 2 0 NMOS L=0.13u W=60.6u        ; M device
R73c 0 1 890                             ; R device
C73d 0 3 23n                             ; C device
C73e 2 1 8.5u                            ; C device
R73f 1 3 8.2M                            ; R device
C73g 1 0 83n                             ; C device
R73h 1 3 675                             ; R device
M73i 1 0 2 3 NMOS L=0.25u W=99.1u AD=95.69p AS=159.65p PD=264.7u PS=300.1u ; M device
M73j 0 2 1 3 PMOS L=0.50u W=80.6u        ; M device
C73k 2 0 500p                            ; C device
M73l 2 3 1 0 NMOS L=1.00u W=3.9u         ; M device
M73m 2 1 0 3 NMOS L=0.18u W=64.6u        ; M device
M73n 1 2 0 3 NMOS L=0.70u W=22.7u        ; M device
M73o 2 3 0 1 NMOS L=0.25u W=35.3u AD=25.33p AS=39.45p PD=86.6u PS=71.9u ; M device
R73p 1 0 43k                             ; R device
M73q 2 3 1 0 PMOS L=0.70u W=26.7u
+ AD=46.00p AS=5.83p PD=79.0u PS=98.4u ; M device
R73r 3 1 20k                             ; R device
M73s 0 1 3 2 NMOS L=0.10u W=1.6u
+ AD=2.51p AS=0.16p PD=3.3u PS=5.4u ; M device
R73t 2 3 90k                             ; R device
C73u 1 0 1.8u                            ; C device
M73v 2 0 3 1 NMOS L=0.18u W=57.8u        ; M device
C73w 1 2 620p                            ; C device
M73x 3 1 0 2 PMOS L=0.70u W=81.5u        ; M device
M73y 0 3 2 1 PMOS L=0.35u W=26.4u
+ AD=39.76p AS=52.46p PD=80.1u PS=63.0u ; M device
M73z 0 2 3 1 PMOS L=0.13u W=13.0u
+ AD=24.49p AS=8.26p PD=48.2u PS=38.6u ; M device
R74a 1 0 70k                             ; R device
C74b 1 3 557p                            ; C device
R74c 2 1 292                             ; R device
M74d 0 1 2 3 NMOS L=0.25u W=37.0u
+ AD=10.73p AS=70.27p PD=126.3u PS=91.2u ; M device
R74e 3 2 87k                             ; R device
M74f 3 2 1 0 NMOS L=0.50u W=7.1u         ; M device
C74g 1 2 248p                            ; C device
R74h 1 2 34                              ; R device
R74i 2 3 9.6M                            ; R device
M74j 3 0 1 2 PMOS L=0.25u W=79.9u        ; M device
M74k 2 3 0 1 NMOS L=0.18u W=28.3u        ; M device
M74l 0 2 1 3 PMOS L=0.25u W=36.9u        ; M device
M74m 2 1 0 3 PMOS L=0.25u W=65.7u        ; M device
C74n 1 0 735p                            ; C device
R74o 1 2 792                             ; R device
M74p 0 1 3 2 NMOS L=0.18u W=69.4u        ; M device
C74q 1 0 9.9u                            ; C device
R74r 0 2 1.6M                            ; R device
C74s 2 3 8.1u                            ; C device
C74t 0 2 28n                             ; C device
C74u 1 3 8.8u                            ; C device
M74v 0 2 1 3 PMOS L=0.50u W=89.8u AD=128.45p AS=129.55p PD=197.4u PS=272.7u ; M device
M74w 0 3 2 1 PMOS L=0.25u W=71.4u
+ AD=128.20p AS=79.51p PD=226.1u PS=200.8u ; M device
R74x 1 2 95k                             ; R device
C74y 3 1 1.2m                            ; C device
M74z 3 0 2 1 NMOS L=0.50u W=91.3u
+ AD=145.17p AS=157.35p PD=187.6u PS=192.4u ; M device
M75a 3 2 1 0 PMOS L=0.18u W=98.6u        ; M device
R75b 2 1 67k                             ; R device
M75c 0 2 3 1 NMOS L=0.13u W=76.7u
+ AD=79.13p AS=90.60p PD=238.2u PS=207.0u ; M device
M75d 2 3 1 0 NMOS L=0.70u W=67.6u        ; M device
C75e 1 2 7.6u                            ; C device
M75f 0 3 2 1 PMOS L=0.70u W=0.7u
+ AD=1.00p AS=1.33p PD=1.6u PS=1.7u ; M device
C75g 1 3 0.8m                            ; C device
R75h 0 3 541                             ; R device
C75i 3 0 1.1u                            ; C device
R75j 1 3 29k                             ; R device
M75k 3 0 2 1 NMOS L=0.10u W=67.9u AD=120.05p AS=67.98p PD=250.1u PS=200.7u ; M device
R75l 3 1 3.9M                            ; R device
R75m 3 2 799                             ; R device
R75n 0 1 15k                             ; R device
C75o 1 3 8.4u                            ; C device
M75p 1 2 0 3 PMOS L=1.00u W=91.6u AD=137.18p AS=78.95p PD=335.5u PS=212.3u ; M device
C75q 1 2 678p                            ; C device
C75r 1 2 73n                             ; C device
M75s 1 3 2 0 PMOS L=0.25u W=36.8u
+ AD=7.23p AS=72.71p PD=111.3u PS=124.4u ; M device
C75t 2 1 1.8u                            ; C device
M75u 3 2 0 1 NMOS L=1.00u W=24.5u AD=48.46p AS=15.94p PD=88.6u PS=67.3u ; M device
C75v 2 1 4.5m                            ; C device
C75w 0 3 7.4m                            ; C device
C75x 2 0 6.5u                            ; C device
M75y 0 1 3 2 PMOS L=1.00u W=8.4u
+ AD=8.34p AS=7.05p PD=31.3u PS=33.1u ; M device
M75z 0 1 3 2 NMOS L=0.50u W=70.0u AD=100.59p AS=50.79p PD=205.6u PS=211.8u ; M device
M76a 3 1 0 2 PMOS L=0.13u W=1.8u         ; M device
R76b 3 2 39k                             ; R device
R76c 3 2 245                             ; R device
C76d 3 0 20n                             ; C device
R76e 2 1 8.2M                            ; R device
M76f 1 2 3 0 NMOS L=0.10u W=81.3u        ; M device
M76g 1 3 0 2 NMOS L=0.70u W=38.6u
+ AD=35.64p AS=37.10p PD=111.2u PS=131.5u ; M device
C76h 1 2 61n                             ; C device
C76i 1 3 199p                            ; C device
C76j 1 0 6.2m                            ; C device
M76k 2 3 1 0 PMOS L=0.70u W=26.7u        ; M device
M76l 3 2 1 0 NMOS L=0.50u W=68.6u        ; M device
R76m 1 0 6                               ; R device
C76n 2 3 1.2u                            ; C device
C76o 0 2 8.7u                            ; C device
C76p 2 1 26n                             ; C device
C76q 0 2 1.1m                            ; C device
M76r 1 3 0 2 PMOS L=0.35u W=53.9u AD=60.10p AS=15.05p PD=155.2u PS=199.1u ; M device
C76s 2 3 8.7u                            ; C device
R76t 0 1 621                             ; R device
M76u 0 2 3 1 PMOS L=0.10u W=64.4u        ; M device
R76v 2 0 100k                            ; R device
C76w 0 3 16n                             ; C device
C76x 2 3 8.8u                            ; C device
C76y 0 1 84n                             ; C device
R76z 1 2 3.7M                            ; R device
R77a 3 0 90k                             ; R device
M77b 3 1 0 2 NMOS L=0.50u W=41.0u        ; M device
C77c 0 1 30n                             ; C device
C77d 0 1 0.9m                            ; C device
C77e 0 2 0.5m                            ; C device
M77f 2 0 3 1 PMOS L=0.25u W=30.7u AD=47.14p AS=21.83p PD=89.8u PS=65.0u ; M device
M77g 1 3 2 0 NMOS L=0.10u W=56.2u        ; M device
R77h 0 1 3.4M                            ; R device
R77i 2 0 552                             ; R device
C77j 2 3 36n                             ; C device
C77k 3 0 75n                             ; C device
M77l 1 0 3 2 PMOS L=0.10u W=52.4u        ; M device
C77m 3 0 5.1m                            ; C device
R77n 2 1 96k                             ; R device
R77o 0 1 1.1M                            ; R device
R77p 0 3 46k                             ; R device
R77q 0 2 817                             ; R device
R77r 2 3 390                             ; R device
M77s 1 2 0 3 PMOS L=0.25u W=83.6u AD=52.81p AS=142.01p PD=258.5u PS=319.9u ; M device
M77t 2 1 0 3 PMOS L=0.18u W=8.0u         ; M device
R77u 3 2 24k                             ; R device
C77v 1 3 2.8u                            ; C device
C77w 1 0 80n                             ; C device
C77x 3 0 2.2u                            ; C device
R77y 1 2 191                             ; R device
M77z 3 1 2 0 NMOS L=1.00u W=70.7u        ; M device
R78a 1 3 82k                             ; R device
C78b 0 3 8.0m                            ; C device
M78c 1 2 3 0 PMOS L=0.50u W=33.4u        ; M device
R78d 3 0 50k                             ; R device
C78e 1 2 111p                            ; C device
M78f 1 0 3 2 NMOS L=0.18u W=55.3u        ; M device
C78g 2 0 681p                            ; C device
M78h 1 3 0 2 PMOS L=0.70u W=91.6u        ; M device
R78i 2 0 7.6M                            ; R device
R78j 0 3 87k                             ; R device
M78k 1 0 2 3 PMOS L=0.25u W=0.6u         ; M device
M78l 2 1 3 0 NMOS L=0.70u W=94.6u
+ AD=90.04p AS=67.40p PD=276.0u PS=356.9u ; M device
M78m 3 2 0 1 PMOS L=0.50u W=48.5u AD=33.87p AS=76.09p PD=135.3u PS=149.8u ; M device
R78n 0 2 131                             ; R device
C78o 3 0 748p                            ; C device
M78p 1 0 3 2 NMOS L=0.10u W=97.1u
+ AD=192.35p AS=134.26p PD=259.6u PS=274.1u ; M device
M78q 2 1 3 0 PMOS L=0.18u W=92.1u        ; M device
C78r 0 1 100n                            ; C device
R78s 0 2 7.0M                            ; R device
M78t 3 2 1 0 PMOS L=0.25u W=95.5u        ; M device
M78u 1 3 2 0 NMOS L=0.10u W=22.5u        ; M device
R78v 0 3 3.2M                            ; R device
R78w 1 0 33k                             ; R device
C78x 1 3 8.2m                            ; C device
M78y 2 0 1 3 NMOS L=0.35u W=86.0u        ; M device
R78z 0 2 127                             ; R device
C79a 3 0 0.2m                            ; C device
C79b 3 0 594p                            ; C device
M79c 1 3 2 0 NMOS L=0.10u W=90.6u        ; M device
R79d 2 3 57k                             ; R device
M79e 1 3 0 2 PMOS L=0.50u W=27.7u
+ AD=30.34p AS=24.67p PD=94.0u PS=76.5u ; M device
M79f 0 3 1 2 PMOS L=0.13u W=14.7u        ; M device
R79g 3 1 947                             ; R device
C79h 1 2 7.7m                            ; C device
R79i 0 2 5.4M                            ; R device
R79j 3 0 216                             ; R device
R79k 3 0 83k                             ; R device
R79l 3 2 5k                              ; R device
R79m 0 2 4k                              ; R device
M79n 3 0 2 1 PMOS L=0.50u W=6.4u
+ AD=10.33p AS=1.44p PD=15.7u PS=17.8u ; M device
R79o 1 2 675                             ; R device
R79p 1 3 741                             ; R device
C79q 1 3 3.1m                            ; C device
M79r 3 1 2 0 PMOS L=1.00u W=29.2u AD=26.40p AS=16.23p PD=73.4u PS=65.9u ; M device
C79s 2 1 9.7m                            ; C device
C79t 3 2 431p                            ; C device
C79u 0 3 51n                             ; C device
M79v 3 0 1 2 PMOS L=0.25u W=90.6u        ; M device
R79w 2 0 84k                             ; R device
M79x 0 3 1 2 PMOS L=0.70u W=45.4u        ; M device
R79y 3 2 535                             ; R device
C79z 2 3 7.5u                            ; C device
M80a 3 2 0 1 PMOS L=0.35u W=77.0u AD=136.63p AS=70.02p PD=300.6u PS=180.8u ; M device
R80b 1 2 1.1M                            ; R device
R80c 0 1 579                             ; R device
R80d 3 2 23k                             ; R device
M80e 3 2 0 1 NMOS L=0.70u W=70.3u AD=50.88p AS=128.55p PD=219.1u PS=280.1u ; M device
R80f 3 0 163                             ; R device
M80g 1 2 0 3 NMOS L=0.35u W=13.7u        ; M device
R80h 1 0 849                             ; R device
C80i 2 0 42n                             ; C device
M80j 3 0 1 2 NMOS L=0.50u W=46.4u
+ AD=10.18p AS=58.37p PD=168.7u PS=177.8u ; M device
C80k 2 3 9.9m                            ; C device
R80l 2 0 64k                             ; R device
C80m 1 2 948p                            ; C device
C80n 1 2 973p                            ; C device
R80o 2 0 501                             ; R device
R80p 1 0 4.2M                            ; R device
C80q 1 2 1.5u                            ; C device
M80r 2 3 1 0 PMOS L=1.00u W=65.4u        ; M device
C80s 1 0 1.1m                            ; C device
M80t 2 1 3 0 PMOS L=1.00u W=45.8u        ; M device
R80u 0 2 722                             ; R device
C80v 2 0 9.1u                            ; C device
M80w 2 1 3 0 NMOS L=0.25u W=14.3u AD=3.22p AS=25.46p PD=35.5u PS=47.7u ; M device
M80x 0 1 2 3 NMOS L=0.70u W=88.3u AD=63.84p AS=150.88p PD=188.0u PS=212.5u ; M device
M80y 2 0 3 1 PMOS L=0.70u W=46.7u        ; M device
M80z 3 1 2 0 PMOS L=0.25u W=37.9u
+ AD=8.53p AS=55.78p PD=76.1u PS=105.9u ; M device
M81a 3 2 0 1 PMOS L=0.13u W=77.0u        ; M device
M81b 2 3 0 1 NMOS L=0.70u W=61.4u AD=39.96p AS=41.89p PD=216.3u PS=224.5u ; M device
C81c 1 0 297p                            ; C device
M81d 0 2 3 1 NMOS L=0.70u W=77.5u        ; M device
M81e 2 1 3 0 NMOS L=0.10u W=9.7u         ; M device
C81f 2 3 0.3m                            ; C device
C81g 1 3 8.4m                            ; C device
R81h 0 1 37                              ; R device
M81i 1 2 0 3 NMOS L=0.18u W=47.6u
+ AD=74.15p AS=53.95p PD=135.9u PS=178.7u ; M device
C81j 2 0 240p                            ; C device
M81k 0 3 2 1 PMOS L=0.50u W=16.4u        ; M device
R81l 1 3 113                             ; R device
R81m 2 1 482                             ; R device
C81n 3 1 64n                             ; C device
C81o 3 2 7n                              ; C device
M81p 0 1 3 2 PMOS L=0.70u W=11.2u        ; M device
R81q 3 1 100k                            ; R device
C81r 3 2 7.3u                            ; C device
M81s 2 0 3 1 NMOS L=0.50u W=1.9u         ; M device
C81t 0 3 7.1m                            ; C device
C81u 3 0 5.6m                            ; C device
R81v 1 3 3.2M                            ; R device
M81w 1 0 2 3 NMOS L=0.18u W=22.1u        ; M device
M81x 0 3 2 1 PMOS L=0.25u W=80.3u
+ AD=14.26p AS=111.73p PD=250.1u PS=212.7u ; M device
R81y 3 2 4k                              ; R device
R81z 3 0 908                             ; R device
R82a 1 2 275                             ; R device
M82b 2 3 0 1 PMOS L=0.70u W=73.8u AD=29.09p AS=140.16p PD=244.4u PS=213.6u ; M device
R82c 0 3 27k                             ; R device
M82d 1 2 3 0 NMOS L=0.18u W=53.4u        ; M device
M82e 3 1 2 0 PMOS L=0.10u W=62.7u
+ AD=75.02p AS=73.52p PD=226.8u PS=248.0u ; M device
M82f 1 0 2 3 PMOS L=0.13u W=9.0u         ; M device
C82g 3 1 5.4u                            ; C device
M82h 0 2 3 1 PMOS L=0.18u W=94.8u        ; M device
R82i 2 1 42k                             ; R device
M82j 2 0 3 1 PMOS L=1.00u W=59.2u        ; M device
M82k 0 1 3 2 PMOS L=1.00u W=92.0u AD=50.50p AS=95.96p PD=257.2u PS=303.7u ; M device
C82l 0 2 57n                             ; C device
C82m 3 1 1.8m                            ; C device
M82n 0 2 1 3 PMOS L=0.70u W=81.7u AD=114.96p AS=76.11p PD=248.2u PS=165.8u ; M device
R82o 0 3 2.4M                            ; R device
M82p 3 2 1 0 NMOS L=0.13u W=96.1u        ; M device
C82q 3 0 74n                             ; C device
R82r 3 1 65k                             ; R device
R82s 0 2 374                             ; R device
M82t 0 2 1 3 PMOS L=0.13u W=15.2u AD=9.93p AS=23.87p PD=46.9u PS=58.4u ; M device
R82u 3 2 27k                             ; R device
R82v 2 1 27k                             ; R device
M82w 3 1 0 2 PMOS L=0.70u W=22.5u AD=15.40p AS=37.51p PD=78.9u PS=80.2u ; M device
M82x 3 2 1 0 NMOS L=0.10u W=9.4u AD=1.72p AS=8.08p PD=29.1u PS=21.7u ; M device
R82y 0 1 9.5M                            ; R device
R82z 2 3 6.9M                            ; R device
R83a 3 0 3.7M                            ; R device
C83b 0 2 8.0m                            ; C device
R83c 1 3 50k                             ; R device
C83d 3 2 8.4u                            ; C device
R83e 2 1 27k                             ; R device
M83f 2 3 0 1 NMOS L=0.25u W=46.5u        ; M device
R83g 2 1 945                             ; R device
C83h 3 2 486p                            ; C device
M83i 1 0 2 3 PMOS L=1.00u W=69.4u        ; M device
C83j 2 0 27n                             ; C device
M83k 1 0 2 3 NMOS L=0.18u W=69.7u AD=124.99p AS=59.60p PD=230.0u PS=203.6u ; M device
C83l 1 2 7.8u                            ; C device
R83m 3 0 373                             ; R device
R83n 3 1 32k                             ; R device
R83o 1 3 75                              ; R device
M83p 1 0 3 2 PMOS L=1.00u W=29.2u AD=41.65p AS=26.54p PD=114.3u PS=111.8u ; M device
C83q 1 2 2.0m                            ; C device
R83r 2 1 6.1M                            ; R device
R83s 0 3 63k                             ; R device
R83t 1 3 758                             ; R device
M83u 2 3 0 1 NMOS L=0.18u W=70.2u        ; M device
R83v 1 0 8.5M                            ; R device
R83w 2 3 44                              ; R device
R83x 2 3 500                             ; R device
R83y 3 2 40                              ; R device
R83z 2 1 0.2M                            ; R device
C84a 1 2 5.5u                            ; C device
M84b 0 2 1 3 NMOS L=0.10u W=60.3u        ; M device
C84c 3 1 6.2m                            ; C device
M84d 0 3 1 2 PMOS L=0.18u W=51.3u        ; M device
R84e 2 0 504                             ; R device
C84f 3 1 7.5u                            ; C device
C84g 1 2 50n                             ; C device
R84h 1 3 68k                             ; R device
M84i 0 1 2 3 PMOS L=0.70u W=21.4u
+ AD=36.85p AS=35.11p PD=83.3u PS=69.8u ; M device
M84j 2 3 0 1 PMOS L=0.70u W=61.4u
+ AD=115.83p AS=25.68p PD=156.8u PS=195.5u ; M device
R84k 3 1 157                             ; R device
M84l 0 2 3 1 NMOS L=0.70u W=24.8u AD=7.91p AS=29.99p PD=60.9u PS=59.8u ; M device
R84m 3 0 102                             ; R device
M84n 3 1 0 2 PMOS L=0.50u W=56.3u
+ AD=84.06p AS=6.28p PD=127.1u PS=193.5u ; M device
C84o 2 3 4.1u                            ; C device
M84p 1 0 2 3 PMOS L=1.00u W=10.8u        ; M device
C84q 3 1 9.5m                            ; C device
C84r 0 2 14n                             ; C device
C84s 0 3 75n                             ; C device
R84t 1 2 781                             ; R device
R84u 2 3 52k                             ; R device
C84v 1 2 991p                            ; C device
R84w 0 3 967                             ; R device
C84x 1 3 1.5u                            ; C device
R84y 0 3 8.7M                            ; R device
R84z 1 0 0.8M                            ; R device
M85a 0 2 3 1 NMOS L=0.25u W=94.4u AD=35.72p AS=170.80p PD=202.0u PS=194.9u ; M device
R85b 1 0 19k                             ; R device
R85c 1 3 6.2M                            ; R device
C85d 2 0 6.7m                            ; C device
R85e 1 2 111                             ; R device
C85f 3 0 88n                             ; C device
R85g 2 3 631                             ; R device
M85h 3 1 2 0 PMOS L=0.10u W=2.3u AD=2.74p AS=0.90p PD=5.2u PS=7.5u ; M device
C85i 0 2 7.8u                            ; C device
M85j 0 3 1 2 NMOS L=0.35u W=27.9u        ; M device
R85k 3 2 33k                             ; R device
C85l 1 2 1.7m                            ; C device
M85m 2 1 3 0 PMOS L=0.50u W=73.7u        ; M device
C85n 1 0 2n                              ; C device
R85o 1 0 3.1M                            ; R device
C85p 0 2 66p                             ; C device
C85q 2 1 39n                             ; C device
M85r 2 1 3 0 PMOS L=0.18u W=52.4u
+ AD=8.50p AS=21.76p PD=183.7u PS=153.4u ; M device
C85s 0 3 623p                            ; C device
R85t 3 2 62k                             ; R device
M85u 0 1 3 2 PMOS L=0.13u W=24.5u        ; M device
R85v 1 0 8.1M                            ; R device
C85w 2 1 255p                            ; C device
M85x 3 1 0 2 PMOS L=0.25u W=3.6u
+ AD=4.82p AS=1.04p PD=9.7u PS=14.0u ; M device
R85y 1 0 8.2M                            ; R device
C85z 1 3 120p                            ; C device
R86a 0 1 541                             ; R device
M86b 1 0 2 3 NMOS L=0.13u W=92.4u        ; M device
M86c 0 3 1 2 NMOS L=0.10u W=47.8u        ; M device
C86d 0 1 257p                            ; C device
R86e 3 1 98k                             ; R device
R86f 3 2 21k                             ; R device
R86g 0 2 881                             ; R device
M86h 1 0 3 2 NMOS L=0.35u W=70.3u        ; M device
M86i 3 1 2 0 NMOS L=0.10u W=73.8u        ; M device
M86j 3 2 0 1 PMOS L=0.35u W=41.1u
+ AD=78.10p AS=77.75p PD=106.7u PS=148.1u ; M device
M86k 2 1 0 3 NMOS L=0.10u W=16.0u AD=22.71p AS=21.27p PD=52.3u PS=61.7u ; M device
C86l 1 2 312p                            ; C device
R86m 1 2 830                             ; R device
M86n 0 3 1 2 NMOS L=0.13u W=49.2u        ; M device
M86o 2 3 1 0 NMOS L=0.70u W=93.1u        ; M device
M86p 2 1 3 0 NMOS L=0.10u W=78.5u        ; M device
M86q 0 3 1 2 PMOS L=0.35u W=32.6u        ; M device
M86r 2 1 0 3 NMOS L=0.13u W=3.6u         ; M device
C86s 3 1 5.2u                            ; C device
R86t 2 0 364                             ; R device
R86u 3 0 7.3M                            ; R device
C86v 2 3 284p                            ; C device
M86w 1 3 2 0 NMOS L=0.25u W=31.8u        ; M device
R86x 2 1 980                             ; R device
M86y 1 0 3 2 PMOS L=0.35u W=86.1u
+ AD=58.58p AS=54.06p PD=229.1u PS=226.7u ; M device
M86z 3 2 0 1 NMOS L=0.13u W=61.5u        ; M device
R87a 3 1 242                             ; R device
M87b 3 0 1 2 PMOS L=0.50u W=62.8u
+ AD=57.00p AS=116.13p PD=197.0u PS=216.5u ; M device
R87c 0 3 19k                             ; R device
R87d 3 0 9.0M                            ; R device
R87e 0 2 317                             ; R device
C87f 1 2 682p                            ; C device
R87g 2 3 46k                             ; R device
R87h 0 2 3.0M                            ; R device
C87i 2 0 705p                            ; C device
C87j 2 1 9.6m                            ; C device
C87k 1 0 2.9u                            ; C device
C87l 1 2 35n                             ; C device
C87m 2 3 3.1m                            ; C device
R87n 0 3 79k                             ; R device
R87o 1 0 26k                             ; R device
C87p 0 1 2.8u                            ; C device
R87q 2 0 321                             ; R device
R87r 0 1 13k                             ; R device
M87s 0 3 1 2 PMOS L=0.70u W=97.2u AD=143.43p AS=105.61p PD=359.2u PS=385.8u ; M device
C87t 0 2 221p                            ; C device
M87u 1 0 2 3 PMOS L=0.35u W=32.0u AD=16.35p AS=58.81p PD=81.5u PS=86.8u ; M device
M87v 1 3 0 2 NMOS L=0.25u W=54.8u        ; M device
R87w 1 0 147                             ; R device
C87x 3 2 24n                             ; C device
C87y 0 1 5.0u                            ; C device
R87z 3 0 72k                             ; R device
C88a 0 2 567p                            ; C device
M88b 2 3 1 0 NMOS L=0.10u W=61.7u
+ AD=24.33p AS=44.22p PD=147.5u PS=171.2u ; M device
R88c 1 3 748                             ; R device
R88d 0 1 702                             ; R device
M88e 1 0 2 3 NMOS L=0.50u W=62.0u
+ AD=111.28p AS=68.55p PD=201.5u PS=232.8u ; M device
R88f 2 0 3.6M                            ; R device
M88g 2 3 1 0 PMOS L=0.50u W=91.3u
+ AD=175.57p AS=122.42p PD=319.5u PS=273.9u ; M device
M88h 3 1 2 0 PMOS L=0.25u W=81.2u        ; M device
M88i 0 1 2 3 NMOS L=0.18u W=97.3u
+ AD=45.01p AS=12.38p PD=312.4u PS=281.0u ; M device
M88j 0 3 1 2 PMOS L=1.00u W=22.0u        ; M device
M88k 1 0 2 3 PMOS L=0.70u W=65.6u        ; M device
C88l 3 0 2.0m                            ; C device
M88m 3 0 2 1 NMOS L=0.50u W=26.0u AD=33.90p AS=49.40p PD=95.5u PS=52.8u ; M device
M88n 0 2 3 1 NMOS L=0.70u W=72.3u
+ AD=96.81p AS=115.95p PD=170.2u PS=246.4u ; M device
M88o 2 1 3 0 NMOS L=0.25u W=54.2u        ; M device
R88p 1 2 0.5M                            ; R device
C88q 3 1 2.6m                            ; C device
M88r 3 1 2 0 PMOS L=0.70u W=35.0u
+ AD=51.82p AS=39.39p PD=115.2u PS=73.5u ; M device
M88s 1 3 0 2 PMOS L=0.50u W=12.9u        ; M device
R88t 1 0 7.5M                            ; R device
M88u 2 3 0 1 NMOS L=0.50u W=92.8u
+ AD=174.92p AS=119.87p PD=305.5u PS=204.4u ; M device
C88v 3 1 677p                            ; C device
C88w 0 3 59n                             ; C device
M88x 0 1 2 3 NMOS L=0.50u W=34.7u        ; M device
R88y 0 1 44k                             ; R device
C88z 2 0 11p                             ; C device
M89a 2 3 1 0 NMOS L=0.70u W=52.6u AD=46.50p AS=13.78p PD=129.4u PS=183.3u ; M device
R89b 1 3 82k                             ; R device
M89c 2 0 3 1 NMOS L=0.25u W=14.5u        ; M device
M89d 2 3 0 1 NMOS L=0.13u W=90.6u        ; M device
R89e 2 0 149                             ; R device
C89f 2 0 2.2u                            ; C device
R89g 2 0 141                             ; R device
M89h 1 3 2 0 NMOS L=0.10u W=11.5u        ; M device
C89i 3 0 3.7u                            ; C device
C89j 3 0 690p                            ; C device
M89k 1 3 2 0 NMOS L=0.70u W=17.3u
+ AD=15.04p AS=15.00p PD=43.6u PS=45.6u ; M device
C89l 2 3 56n                             ; C device
C89m 2 0 149p                            ; C device
R89n 0 1 6.3M                            ; R device
C89o 0 1 4.4m                            ; C device
M89p 2 0 1 3 PMOS L=0.10u W=78.7u        ; M device
M89q 2 3 0 1 PMOS L=0.13u W=22.4u AD=20.20p AS=35.70p PD=54.6u PS=82.8u ; M device
R89r 1 0 56                              ; R device
M89s 2 1 3 0 PMOS L=0.25u W=4.6u AD=4.67p AS=4.47p PD=13.1u PS=13.0u ; M device
M89t 1 3 0 2 PMOS L=1.00u W=17.5u        ; M device
M89u 1 2 0 3 PMOS L=0.10u W=77.7u AD=80.66p AS=57.65p PD=249.8u PS=258.2u ; M device
R89v 0 3 2k                              ; R device
R89w 0 1 110                             ; R device
C89x 2 0 7.0m                            ; C device
M89y 0 2 3 1 PMOS L=0.50u W=37.7u        ; M device
C89z 2 3 9.4u                            ; C device
M90a 2 3 1 0 NMOS L=0.50u W=6.5u AD=7.35p AS=12.35p PD=13.7u PS=21.5u ; M device
C90b 2 0 8.2m                            ; C device
M90c 0 1 3 2 NMOS L=0.25u W=23.2u        ; M device
C90d 0 3 295p                            ; C device
M90e 3 1 0 2 PMOS L=1.00u W=18.8u        ; M device
M90f 3 2 0 1 PMOS L=0.10u W=6.3u
+ AD=6.85p AS=7.85p PD=14.4u PS=14.4u ; M device
R90g 2 1 18k                             ; R device
M90h 2 3 0 1 NMOS L=0.13u W=64.0u AD=119.87p AS=19.91p PD=217.5u PS=243.7u ; M device
R90i 1 3 90k                             ; R device
C90j 1 2 0.3m                            ; C device
C90k 1 2 144p                            ; C device
C90l 3 0 4.7m                            ; C device
C90m 0 3 7.0u                            ; C device
M90n 3 1 0 2 NMOS L=0.25u W=97.8u        ; M device
M90o 2 0 3 1 NMOS L=0.50u W=93.8u
+ AD=88.35p AS=67.80p PD=287.3u PS=319.3u ; M device
C90p 0 1 8.9m                            ; C device
R90q 3 0 242                             ; R device
M90r 1 2 0 3 NMOS L=0.13u W=68.8u        ; M device
C90s 1 3 9.1u                            ; C device
R90t 2 3 5.5M                            ; R device
M90u 1 3 2 0 PMOS L=0.13u W=76.8u        ; M device
M90v 2 0 3 1 PMOS L=0.10u W=89.2u        ; M device
M90w 2 3 0 1 NMOS L=0.10u W=43.3u        ; M device
M90x 3 2 0 1 PMOS L=0.18u W=70.6u AD=118.43p AS=111.40p PD=193.3u PS=199.1u ; M device
M90y 1 3 2 0 PMOS L=0.35u W=88.2u        ; M device
R90z 1 0 60k                             ; R device
R91a 0 3 78k                             ; R device
R91b 1 3 492                             ; R device
C91c 3 0 6.4u                            ; C device
M91d 2 0 1 3 PMOS L=0.70u W=97.8u        ; M device
C91e 3 2 7.8m                            ; C device
C91f 1 0 52n                             ; C device
C91g 1 0 49n                             ; C device
C91h 1 0 73p                             ; C device
R91i 3 2 582                             ; R device
R91j 0 3 90                              ; R device
C91k 3 1 1.1m                            ; C device
R91l 1 2 8k                              ; R device
R91m 3 0 36k                             ; R device
R91n 2 0 8.6M                            ; R device
R91o 3 0 55k                             ; R device
R91p 1 2 5.1M                            ; R device
R91q 0 2 8.4M                            ; R device
C91r 0 3 6.4u                            ; C device
M91s 2 0 1 3 NMOS L=0.18u W=4.0u         ; M device
C91t 0 1 943p                            ; C device
M91u 1 2 0 3 PMOS L=0.25u W=15.2u        ; M device
C91v 3 0 5.9u                            ; C device
R91w 0 3 22k                             ; R device
M91x 1 2 0 3 NMOS L=0.25u W=50.3u
+ AD=47.76p AS=67.79p PD=148.7u PS=139.0u ; M device
C91y 1 0 747p                            ; C device
M91z 1 3 0 2 PMOS L=0.10u W=33.7u
+ AD=6.60p AS=14.69p PD=124.6u PS=75.0u ; M device
C92a 1 2 22n                             ; C device
M92b 0 2 1 3 NMOS L=0.10u W=43.7u        ; M device
R92c 2 3 48k                             ; R device
M92d 0 2 1 3 NMOS L=0.10u W=20.3u        ; M device
R92e 2 3 6.9M                            ; R device
R92f 1 3 93k                             ; R device
M92g 0 1 3 2 NMOS L=1.00u W=95.8u AD=135.71p AS=93.06p PD=252.7u PS=210.9u ; M device
R92h 2 0 720                             ; R device
C92i 3 0 43n                             ; C device
R92j 1 2 52k                             ; R device
C92k 0 3 1.7u                            ; C device
R92l 0 2 569                             ; R device
R92m 0 1 945                             ; R device
C92n 1 3 0.7u                            ; C device
M92o 3 1 0 2 PMOS L=0.10u W=59.4u
+ AD=22.19p AS=65.87p PD=139.9u PS=155.3u ; M device
R92p 1 3 7.4M                            ; R device
R92q 0 3 9.4M                            ; R device
M92r 2 1 0 3 PMOS L=0.10u W=66.2u AD=77.02p AS=51.22p PD=238.5u PS=217.3u ; M device
C92s 1 0 5.3u                            ; C device
R92t 3 0 517                             ; R device
M92u 3 1 2 0 NMOS L=0.13u W=18.3u        ; M device
R92v 2 1 40k                             ; R device
R92w 3 1 81k                             ; R device
M92x 0 2 3 1 NMOS L=0.50u W=22.4u        ; M device
M92y 3 1 2 0 NMOS L=0.10u W=21.9u        ; M device
R92z 1 0 3.8M                            ; R device
M93a 2 3 1 0 NMOS L=0.35u W=42.0u        ; M device
R93b 1 0 53k                             ; R device
R93c 2 0 512                             ; R device
M93d 3 0 2 1 NMOS L=0.13u W=92.2u AD=158.37p AS=150.64p PD=244.0u PS=317.5u ; M device
M93e 2 3 0 1 NMOS L=0.35u W=86.9u        ; M device
C93f 3 2 7.9m                            ; C device
M93g 0 3 2 1 PMOS L=1.00u W=92.5u AD=137.43p AS=166.03p PD=192.3u PS=289.7u ; M device
C93h 0 1 120p                            ; C device
M93i 0 3 1 2 PMOS L=0.13u W=76.2u        ; M device
R93j 0 2 2.8M                            ; R device
C93k 0 2 972p                            ; C device
R93l 2 3 414                             ; R device
R93m 1 2 77k                             ; R device
C93n 1 0 597p                            ; C device
C93o 0 3 3.3u                            ; C device
M93p 3 1 2 0 PMOS L=0.50u W=1.2u
+ AD=0.86p AS=1.49p PD=2.4u PS=3.6u ; M device
C93q 2 1 6.7u                            ; C device
M93r 2 1 3 0 NMOS L=0.50u W=73.7u
+ AD=70.03p AS=130.05p PD=210.1u PS=240.0u ; M device
M93s 0 2 3 1 NMOS L=0.50u W=30.9u        ; M device
C93t 0 1 28n                             ; C device
R93u 2 0 62k                             ; R device
R93v 2 1 6.2M                            ; R device
R93w 1 3 74k                             ; R device
M93x 3 0 2 1 PMOS L=0.18u W=88.6u        ; M device
M93y 2 3 1 0 PMOS L=0.13u W=29.2u        ; M device
C93z 2 3 108p                            ; C device
C94a 1 2 3.1m                            ; C device
R94b 3 2 532                             ; R device
M94c 2 0 1 3 PMOS L=0.70u W=35.6u AD=18.97p AS=36.75p PD=131.0u PS=113.8u ; M device
M94d 1 2 0 3 PMOS L=0.18u W=99.3u        ; M device
R94e 1 0 1k                              ; R device
M94f 2 1 3 0 PMOS L=0.35u W=26.3u        ; M device
C94g 2 1 634p                            ; C device
R94h 0 3 2.0M                            ; R device
M94i 0 3 2 1 PMOS L=0.18u W=86.6u        ; M device
C94j 2 3 2.5u                            ; C device
M94k 0 1 2 3 PMOS L=0.25u W=76.2u
+ AD=140.00p AS=65.69p PD=216.7u PS=222.1u ; M device
C94l 2 0 9.0m                            ; C device
C94m 0 3 3.2m                            ; C device
C94n 0 2 1.2m                            ; C device
C94o 3 2 94n                             ; C device
R94p 2 0 8.5M                            ; R device
M94q 1 3 0 2 NMOS L=0.18u W=60.7u AD=37.86p AS=30.90p PD=224.3u PS=225.8u ; M device
R94r 3 1 41k                             ; R device
C94s 2 1 688p                            ; C device
M94t 1 0 2 3 NMOS L=1.00u W=87.3u        ; M device
R94u 3 1 374                             ; R device
R94v 2 3 40k                             ; R device
R94w 3 1 2.7M                            ; R device
M94x 0 3 1 2 NMOS L=1.00u W=24.8u        ; M device
R94y 2 0 67k                             ; R device
C94z 1 2 4.6m                            ; C device
M95a 2 3 0 1 NMOS L=0.50u W=54.7u
+ AD=72.54p AS=45.99p PD=213.2u PS=132.7u ; M device
R95b 0 3 5.0M                            ; R device
R95c 2 3 2.2M                            ; R device
M95d 2 1 0 3 NMOS L=0.50u W=1.9u
+ AD=2.39p AS=1.93p PD=5.9u PS=5.1u ; M device
R95e 3 1 8.6M                            ; R device
C95f 2 0 6.1u                            ; C device
C95g 2 1 544p                            ; C device
C95h 2 0 275p                            ; C device
C95i 2 3 730p                            ; C device
C95j 1 3 6.9m                            ; C device
R95k 2 1 361                             ; R device
C95l 3 0 6.6m                            ; C device
R95m 2 1 66k                             ; R device
C95n 0 1 9.2m                            ; C device
R95o 3 1 283                             ; R device
R95p 1 3 446                             ; R device
C95q 0 1 9n                              ; C device
R95r 1 3 20                              ; R device
C95s 3 1 316p                            ; C device
C95t 0 2 177p                            ; C device
R95u 3 2 18k                             ; R device
R95v 0 2 382                             ; R device
C95w 0 2 531p                            ; C device
C95x 0 3 90n                             ; C device
R95y 2 1 95                              ; R device
C95z 2 1 772p                            ; C device
R96a 1 3 2.9M                            ; R device
M96b 3 2 1 0 NMOS L=0.13u W=50.1u        ; M device
M96c 3 2 1 0 NMOS L=0.18u W=3.3u AD=1.54p AS=1.46p PD=11.9u PS=8.0u ; M device
R96d 3 2 43k                             ; R device
C96e 2 0 784p                            ; C device
C96f 0 3 6.8u                            ; C device
C96g 0 3 30p                             ; C device
M96h 0 2 1 3 NMOS L=0.25u W=27.6u
+ AD=34.84p AS=7.55p PD=60.2u PS=80.6u ; M device
R96i 1 3 66k                             ; R device
C96j 2 3 7.4m                            ; C device
R96k 2 0 2.0M                            ; R device
M96l 3 2 0 1 NMOS L=0.50u W=26.6u        ; M device
M96m 2 0 3 1 PMOS L=0.10u W=18.6u        ; M device
R96n 1 0 521                             ; R device
M96o 1 3 0 2 NMOS L=0.50u W=18.4u
+ AD=13.38p AS=7.01p PD=44.0u PS=52.3u ; M device
C96p 2 1 72n                             ; C device
C96q 2 1 51n                             ; C device
M96r 3 2 0 1 NMOS L=0.50u W=84.3u        ; M device
C96s 1 2 4.4m                            ; C device
R96t 1 3 125                             ; R device
M96u 2 1 0 3 PMOS L=0.35u W=33.5u
+ AD=36.99p AS=20.54p PD=68.3u PS=97.4u ; M device
C96v 2 3 8.2u                            ; C device
R96w 2 3 88k                             ; R device
C96x 2 1 831p                            ; C device
M96y 3 1 2 0 NMOS L=0.70u W=87.3u AD=47.10p AS=36.01p PD=263.1u PS=184.1u ; M device
R96z 2 3 3.0M                            ; R device
R97a 1 3 5.2M                            ; R device
R97b 0 3 6k                              ; R device
M97c 1 0 3 2 PMOS L=0.13u W=87.7u        ; M device
M97d 1 0 3 2 NMOS L=1.00u W=8.0u AD=5.21p AS=15.49p PD=20.2u PS=27.4u ; M device
C97e 3 0 0.2m                            ; C device
M97f 0 2 1 3 PMOS L=0.70u W=76.7u        ; M device
C97g 1 2 1.3m                            ; C device
C97h 2 0 9.5m                            ; C device
C97i 0 2 1.5u                            ; C device
R97j 3 0 90k                             ; R device
R97k 2 1 50k                             ; R device
M97l 2 3 1 0 NMOS L=0.13u W=75.0u        ; M device
R97m 2 0 8.4M                            ; R device
R97n 2 1 68k                             ; R device
R97o 3 0 618                             ; R device
M97p 1 0 2 3 NMOS L=0.50u W=21.9u        ; M device
R97q 0 3 96k                             ; R device
R97r 1 3 175                             ; R device
R97s 1 2 98k                             ; R device
C97t 1 0 2.5m                            ; C device
M97u 3 2 1 0 NMOS L=1.00u W=36.1u AD=60.42p AS=20.69p PD=90.4u PS=76.0u ; M device
R97v 3 0 251                             ; R device
R97w 0 2 5k                              ; R device
R97x 1 0 66k                             ; R device
C97y 2 3 9.1m                            ; C device
M97z 2 1 0 3 PMOS L=1.00u W=98.0u AD=110.68p AS=159.82p PD=225.5u PS=383.8u ; M device
M98a 0 3 1 2 PMOS L=0.18u W=41.3u
+ AD=25.06p AS=54.34p PD=98.2u PS=105.5u ; M device
R98b 3 1 64k                             ; R device
R98c 1 2 78k                             ; R device
R98d 2 1 194                             ; R device
M98e 2 0 1 3 PMOS L=0.70u W=98.1u        ; M device
M98f 2 3 1 0 NMOS L=0.10u W=90.1u AD=143.36p AS=37.38p PD=207.2u PS=220.2u ; M device
C98g 3 1 239p                            ; C device
C98h 3 0 673p                            ; C device
M98i 3 0 2 1 PMOS L=0.50u W=52.9u AD=53.27p AS=39.91p PD=137.9u PS=145.4u ; M device
M98j 3 1 0 2 NMOS L=1.00u W=60.6u
+ AD=119.35p AS=96.52p PD=213.7u PS=174.9u ; M device
C98k 3 1 9.4m                            ; C device
C98l 2 1 813p                            ; C device
R98m 0 1 1.0M                            ; R device
C98n 2 3 90p                             ; C device
C98o 1 2 5.2u                            ; C device
R98p 0 2 645                             ; R device
R98q 0 2 536                             ; R device
M98r 0 1 3 2 NMOS L=0.25u W=34.5u        ; M device
C98s 2 1 0.2u                            ; C device
C98t 1 0 19n                             ; C device
M98u 2 1 0 3 PMOS L=0.35u W=72.7u        ; M device
R98v 2 0 5.7M                            ; R device
R98w 1 2 38k                             ; R device
M98x 0 3 2 1 NMOS L=0.50u W=85.5u AD=19.71p AS=50.22p PD=256.5u PS=217.4u ; M device
C98y 1 2 91n                             ; C device
R98z 1 2 903                             ; R device
M99a 1 2 0 3 PMOS L=0.35u W=82.8u AD=148.97p AS=128.00p PD=193.8u PS=289.1u ; M device
M99b 2 3 1 0 PMOS L=0.13u W=4.7u         ; M device
M99c 2 0 1 3 PMOS L=0.50u W=61.0u AD=93.24p AS=22.24p PD=168.1u PS=137.9u ; M device
C99d 3 0 554p                            ; C device
M99e 1 3 0 2 PMOS L=0.50u W=99.3u AD=73.18p AS=28.45p PD=350.3u PS=214.9u ; M device
R99f 1 0 678                             ; R device
R99g 0 3 114                             ; R device
M99h 3 1 2 0 PMOS L=0.25u W=78.6u AD=64.24p AS=57.51p PD=211.1u PS=202.9u ; M device
M99i 0 2 3 1 PMOS L=0.70u W=31.0u        ; M device
C99j 3 0 3.8m                            ; C device
M99k 3 1 0 2 NMOS L=0.50u W=51.9u
+ AD=38.02p AS=32.07p PD=192.8u PS=114.4u ; M device
R99l 2 1 784                             ; R device
M99m 1 0 2 3 PMOS L=1.00u W=91.7u        ; M device
M99n 0 1 2 3 PMOS L=0.18u W=63.5u        ; M device
R99o 3 1 397                             ; R device
C99p 1 3 195p                            ; C device
M99q 3 0 1 2 NMOS L=1.00u W=74.6u
+ AD=120.58p AS=70.51p PD=169.9u PS=232.0u ; M device
C99r 1 3 226p                            ; C device
M99s 3 2 0 1 PMOS L=1.00u W=57.2u
+ AD=23.77p AS=95.94p PD=131.0u PS=193.4u ; M device
R99t 3 1 645                             ; R device
M99u 1 0 2 3 PMOS L=0.10u W=71.0u        ; M device
R99v 0 2 4.2M                            ; R device
M99w 2 1 3 0 NMOS L=0.10u W=82.4u        ; M device
C99x 3 2 4.2u                            ; C device
C99y 3 2 9.7m                            ; C device
M99z 2 0 1 3 PMOS L=0.50u W=23.5u
+ AD=26.44p AS=28.22p PD=48.7u PS=62.5u ; M device
M100a 2 1 0 3 NMOS L=0.35u W=96.6u
+ AD=97.82p AS=21.61p PD=355.4u PS=275.6u ; M device
R100b 0 3 66k                            ; R device
C100c 2 0 2.7u                           ; C device
M100d 3 2 1 0 PMOS L=1.00u W=24.9u       ; M device
R100e 3 2 72k                            ; R device
R100f 3 2 7.6M                           ; R device
C100g 2 0 1.8m                           ; C device
C100h 3 0 136p                           ; C device
M100i 3 2 1 0 NMOS L=1.00u W=94.8u       ; M device
R100j 1 3 547                            ; R device
C100k 1 0 80n                            ; C device
M100l 3 2 0 1 NMOS L=0.70u W=86.7u
+ AD=95.76p AS=137.98p PD=282.4u PS=209.0u ; M device
R100m 2 0 49k                            ; R device
M100n 1 2 0 3 PMOS L=0.35u W=95.3u       ; M device
R100o 2 0 7.3M                           ; R device
C100p 1 0 8.6u                           ; C device
M100q 1 2 3 0 NMOS L=0.10u W=58.3u       ; M device
M100r 1 3 2 0 NMOS L=0.50u W=74.1u
+ AD=24.84p AS=43.79p PD=241.3u PS=169.5u ; M device
M100s 1 0 2 3 NMOS L=1.00u W=19.0u       ; M device
M100t 1 3 0 2 NMOS L=1.00u W=55.9u AD=92.26p AS=57.15p PD=165.9u PS=137.5u ; M device
M100u 1 3 0 2 NMOS L=0.50u W=21.7u       ; M device
R100v 0 2 182                            ; R device
R100w 2 0 214                            ; R device
R100x 2 0 423                            ; R device
C100y 3 1 8.1m                           ; C device
M100z 3 0 1 2 PMOS L=0.50u W=83.0u AD=148.23p AS=37.13p PD=221.4u PS=190.3u ; M device
R101a 2 1 45k                            ; R device
C101b 1 2 8.5u                           ; C device
C101c 3 1 3.7m                           ; C device
R101d 0 2 6.8M                           ; R device
M101e 1 2 0 3 NMOS L=0.50u W=27.3u       ; M device
R101f 2 3 923                            ; R device
R101g 2 0 2k                             ; R device
C101h 3 1 736p                           ; C device
M101i 2 0 1 3 NMOS L=0.13u W=52.9u       ; M device
R101j 1 0 9.2M                           ; R device
M101k 0 2 1 3 PMOS L=0.13u W=77.2u AD=150.57p AS=7.97p PD=306.1u PS=227.2u ; M device
C101l 1 0 4n                             ; C device
R101m 1 2 52k                            ; R device
M101n 3 2 1 0 PMOS L=0.70u W=60.2u       ; M device
R101o 3 1 388                            ; R device
C101p 3 1 743p                           ; C device
M101q 2 1 3 0 NMOS L=0.35u W=5.1u
+ AD=2.76p AS=9.47p PD=14.4u PS=18.3u ; M device
C101r 2 1 693p                           ; C device
R101s 1 0 2                              ; R device
R101t 3 1 89k                            ; R device
C101u 2 0 6.4m                           ; C device
R101v 1 3 1.2M                           ; R device
M101w 1 3 0 2 PMOS L=0.10u W=89.5u       ; M device
R101x 1 2 67k                            ; R device
R101y 3 1 8.1M                           ; R device
R101z 3 0 54k                            ; R device
C102a 3 2 4.3m                           ; C device
M102b 2 3 1 0 NMOS L=1.00u W=10.4u
+ AD=6.77p AS=1.44p PD=27.1u PS=35.5u ; M device
M102c 3 1 2 0 NMOS L=0.50u W=48.5u       ; M device
R102d 2 1 0.6M                           ; R device
R102e 2 3 1.6M                           ; R device
M102f 3 2 0 1 NMOS L=0.50u W=10.3u       ; M device
M102g 2 3 1 0 PMOS L=0.35u W=37.3u       ; M device
R102h 3 1 31k                            ; R device
R102i 1 0 748                            ; R device
R102j 1 2 2.2M                           ; R device
M102k 1 0 3 2 NMOS L=0.18u W=25.4u       ; M device
C102l 0 1 9.4m                           ; C device
R102m 2 3 2.1M                           ; R device
M102n 3 1 0 2 NMOS L=0.18u W=38.7u       ; M device
M102o 3 1 0 2 NMOS L=0.13u W=18.6u       ; M device
R102p 3 0 1.0M                           ; R device
R102q 3 1 749                            ; R device
R102r 2 3 12k                            ; R device
C102s 3 0 1.0u                           ; C device
R102t 3 1 5.5M                           ; R device
C102u 2 0 819p                           ; C device
M102v 2 3 1 0 PMOS L=0.18u W=55.8u AD=96.72p AS=38.27p PD=202.0u PS=122.8u ; M device
M102w 1 3 0 2 NMOS L=0.70u W=48.7u
+ AD=33.94p AS=71.57p PD=97.4u PS=190.3u ; M device
M102x 2 0 1 3 NMOS L=1.00u W=98.2u       ; M device
C102y 0 1 3.5m                           ; C device
R102z 3 2 0.5M                           ; R device
M103a 0 2 3 1 NMOS L=0.18u W=22.5u       ; M device
C103b 2 0 151p                           ; C device
M103c 0 2 1 3 NMOS L=0.10u W=52.0u       ; M device
C103d 2 0 2.2m                           ; C device
M103e 2 0 1 3 NMOS L=0.50u W=33.5u       ; M device
M103f 0 2 1 3 PMOS L=0.70u W=79.9u AD=26.78p AS=138.19p PD=196.4u PS=305.2u ; M device
C103g 0 2 31n                            ; C device
C103h 1 0 0.1u                           ; C device
M103i 0 3 2 1 PMOS L=0.18u W=14.6u
+ AD=5.28p AS=12.08p PD=37.8u PS=36.1u ; M device
R103j 0 1 466                            ; R device
R103k 0 1 76                             ; R device
C103l 1 2 2.9u                           ; C device
C103m 2 0 0.6u                           ; C device
R103n 0 1 102                            ; R device
C103o 2 3 3.7u                           ; C device
R103p 3 0 673                            ; R device
R103q 0 1 1                              ; R device
R103r 0 3 542                            ; R device
R103s 0 2 5.3M                           ; R device
C103t 3 0 7.1u                           ; C device
C103u 1 3 4.4u                           ; C device
C103v 1 3 72p                            ; C device
M103w 0 3 1 2 NMOS L=1.00u W=36.8u       ; M device
R103x 1 2 41k                            ; R device
R103y 1 3 4.6M                           ; R device
C103z 2 0 0.2m                           ; C device
M104a 3 1 0 2 NMOS L=0.35u W=3.9u
+ AD=0.68p AS=6.00p PD=8.8u PS=12.5u ; M device
M104b 2 0 3 1 NMOS L=0.35u W=66.2u       ; M device
M104c 1 2 3 0 NMOS L=0.25u W=22.3u       ; M device
C104d 1 0 4.4u                           ; C device
R104e 3 0 3.2M                           ; R device
M104f 2 0 3 1 PMOS L=0.10u W=72.5u       ; M device
M104g 1 3 0 2 PMOS L=0.25u W=85.4u       ; M device
C104h 0 1 675p                           ; C device
R104i 3 2 151                            ; R device
R104j 1 2 64k                            ; R device
R104k 2 1 880                            ; R device
C104l 3 2 19n                            ; C device
M104m 1 3 2 0 PMOS L=0.25u W=15.1u       ; M device
M104n 1 2 3 0 PMOS L=0.18u W=79.1u       ; M device
C104o 3 0 8.8u                           ; C device
R104p 2 1 287                            ; R device
C104q 3 0 4.6u                           ; C device
R104r 3 2 52k                            ; R device
C104s 3 0 24n                            ; C device
C104t 0 1 50n                            ; C device
C104u 1 0 8.1u                           ; C device
C104v 2 1 92n                            ; C device
C104w 2 1 74n                            ; C device
R104x 2 1 9.6M                           ; R device
R104y 1 2 65k                            ; R device
M104z 3 0 1 2 NMOS L=0.50u W=40.9u
+ AD=70.00p AS=75.91p PD=155.9u PS=151.6u ; M device
M105a 2 3 0 1 NMOS L=1.00u W=14.3u
+ AD=11.30p AS=24.52p PD=45.0u PS=52.3u ; M device
M105b 0 1 3 2 PMOS L=0.10u W=16.2u
+ AD=20.29p AS=15.85p PD=60.6u PS=42.0u ; M device
C105c 2 0 148p                           ; C device
R105d 2 1 352                            ; R device
M105e 1 0 3 2 NMOS L=0.35u W=84.4u       ; M device
M105f 1 0 3 2 PMOS L=0.50u W=26.5u
+ AD=4.88p AS=11.44p PD=75.5u PS=104.5u ; M device
M105g 3 0 2 1 NMOS L=0.18u W=46.8u       ; M device
M105h 2 3 0 1 NMOS L=0.70u W=59.0u       ; M device
R105i 3 0 79                             ; R device
C105j 2 3 8n                             ; C device
C105k 1 0 481p                           ; C device
C105l 1 3 0.3m                           ; C device
R105m 0 1 87k                            ; R device
C105n 2 3 9.1u                           ; C device
M105o 1 0 3 2 NMOS L=1.00u W=30.7u       ; M device
C105p 3 0 4.8m                           ; C device
R105q 2 3 75                             ; R device
C105r 3 1 30n                            ; C device
C105s 2 3 583p                           ; C device
R105t 1 3 1.1M                           ; R device
R105u 3 1 4.3M                           ; R device
C105v 1 0 8.2u                           ; C device
M105w 0 1 2 3 NMOS L=0.10u W=73.7u       ; M device
R105x 0 3 628                            ; R device
C105y 1 2 93n                            ; C device
C105z 1 0 5n                             ; C device
C106a 2 0 10n                            ; C device
C106b 2 0 8.5u                           ; C device
M106c 3 1 2 0 PMOS L=0.13u W=2.4u        ; M device
M106d 0 2 3 1 NMOS L=1.00u W=68.5u       ; M device
C106e 3 2 8.8u                           ; C device
R106f 3 1 469                            ; R device
R106g 1 3 692                            ; R device
R106h 2 1 4.8M                           ; R device
M106i 1 0 3 2 PMOS L=0.13u W=32.3u
+ AD=31.04p AS=16.10p PD=96.4u PS=106.1u ; M device
C106j 2 1 2.7u                           ; C device
C106k 0 3 7.8m                           ; C device
R106l 3 0 2.0M                           ; R device
R106m 2 1 65k                            ; R device
R106n 1 2 1.7M                           ; R device
C106o 2 0 1.2m                           ; C device
C106p 2 1 48n                            ; C device
C106q 3 1 7.9m                           ; C device
C106r 2 1 169p                           ; C device
C106s 3 1 435p                           ; C device
C106t 3 1 824p                           ; C device
R106u 2 3 10k                            ; R device
M106v 0 2 3 1 NMOS L=0.18u W=56.6u
+ AD=34.14p AS=87.79p PD=182.1u PS=224.3u ; M device
M106w 2 3 0 1 PMOS L=0.13u W=83.0u AD=45.27p AS=45.41p PD=246.2u PS=309.5u ; M device
M106x 1 0 3 2 NMOS L=0.50u W=96.0u AD=53.45p AS=19.71p PD=269.9u PS=211.1u ; M device
M106y 2 1 0 3 PMOS L=1.00u W=46.0u       ; M device
M106z 1 3 2 0 PMOS L=1.00u W=4.7u        ; M device
R107a 1 2 85                             ; R device
M107b 2 0 1 3 NMOS L=1.00u W=68.5u AD=97.62p AS=65.69p PD=233.3u PS=217.4u ; M device
C107c 1 0 7n                             ; C device
M107d 1 0 2 3 NMOS L=1.00u W=75.9u       ; M device
R107e 2 1 376                            ; R device
R107f 1 0 0.5M                           ; R device
R107g 3 1 2.3M                           ; R device
M107h 1 3 2 0 PMOS L=0.25u W=96.9u AD=129.69p AS=17.27p PD=314.4u PS=316.7u ; M device
M107i 3 0 1 2 PMOS L=0.18u W=36.7u       ; M device
M107j 1 0 3 2 PMOS L=0.25u W=31.1u       ; M device
M107k 3 1 2 0 PMOS L=0.10u W=80.0u       ; M device
C107l 3 1 881p                           ; C device
R107m 0 1 364                            ; R device
R107n 0 3 317                            ; R device
R107o 0 1 776                            ; R device
R107p 0 3 83k                            ; R device
C107q 3 2 6.7u                           ; C device
C107r 0 1 1.9u                           ; C device
C107s 3 1 848p                           ; C device
C107t 3 2 13n                            ; C device
M107u 3 1 2 0 PMOS L=0.13u W=46.8u       ; M device
M107v 2 3 1 0 NMOS L=0.50u W=64.4u
+ AD=14.31p AS=39.12p PD=249.5u PS=147.0u ; M device
R107w 0 3 75k                            ; R device
C107x 1 0 52n                            ; C device
C107y 0 1 6.8m                           ; C device
M107z 2 3 1 0 PMOS L=0.10u W=76.5u AD=143.07p AS=69.40p PD=238.8u PS=271.4u ; M device
M108a 3 0 1 2 NMOS L=0.13u W=30.0u       ; M device
R108b 2 3 677                            ; R device
M108c 1 0 3 2 PMOS L=0.70u W=92.4u AD=154.01p AS=18.63p PD=273.3u PS=347.8u ; M device
C108d 2 1 216p                           ; C device
M108e 2 3 1 0 PMOS L=0.50u W=79.0u       ; M device
M108f 2 1 3 0 PMOS L=0.25u W=10.6u
+ AD=20.15p AS=3.65p PD=41.8u PS=39.4u ; M device
R108g 1 3 928                            ; R device
M108h 2 1 3 0 PMOS L=0.25u W=28.2u AD=42.12p AS=54.14p PD=112.9u PS=108.3u ; M device
M108i 2 1 3 0 PMOS L=0.13u W=73.6u
+ AD=84.28p AS=105.98p PD=147.3u PS=200.1u ; M device
R108j 2 0 123                            ; R device
M108k 3 2 1 0 PMOS L=0.13u W=27.7u       ; M device
C108l 0 1 1n                             ; C device
C108m 0 3 6.9m                           ; C device
C108n 1 3 4.4m                           ; C device
R108o 2 0 403                            ; R device
M108p 1 0 2 3 PMOS L=0.13u W=28.8u       ; M device
C108q 1 0 744p                           ; C device
M108r 2 3 0 1 PMOS L=0.70u W=28.3u AD=32.60p AS=22.16p PD=92.2u PS=83.8u ; M device
R108s 2 3 0.7M                           ; R device
M108t 3 2 1 0 NMOS L=0.25u W=26.0u AD=28.91p AS=7.68p PD=78.0u PS=56.8u ; M device
R108u 2 1 64k                            ; R device
M108v 0 2 3 1 PMOS L=0.35u W=93.5u
+ AD=170.05p AS=52.89p PD=299.8u PS=288.2u ; M device
R108w 0 2 70k                            ; R device
M108x 2 3 1 0 PMOS L=0.70u W=42.2u
+ AD=29.58p AS=74.29p PD=166.2u PS=97.4u ; M device
C108y 3 0 500p                           ; C device
C108z 0 1 94n                            ; C device
M109a 2 3 0 1 NMOS L=0.70u W=64.0u AD=101.95p AS=52.49p PD=165.1u PS=128.2u ; M device
C109b 3 1 596p                           ; C device
C109c 3 1 9.5u                           ; C device
C109d 1 0 43n                            ; C device
C109e 1 3 9.1m                           ; C device
R109f 2 0 91k                            ; R device
M109g 2 1 3 0 NMOS L=0.10u W=94.4u       ; M device
M109h 2 3 0 1 NMOS L=0.50u W=49.0u AD=48.27p AS=21.49p PD=103.1u PS=165.6u ; M device
M109i 3 0 1 2 PMOS L=0.25u W=80.4u       ; M device
R109j 1 2 91k                            ; R device
R109k 3 2 90k                            ; R device
M109l 0 2 1 3 NMOS L=0.13u W=39.2u
+ AD=39.88p AS=69.51p PD=151.3u PS=143.8u ; M device
M109m 0 2 3 1 PMOS L=0.25u W=4.3u        ; M device
M109n 1 0 2 3 NMOS L=0.50u W=15.3u AD=6.90p AS=22.20p PD=38.9u PS=49.6u ; M device
R109o 0 1 5.8M                           ; R device
R109p 3 1 968                            ; R device
M109q 2 0 3 1 PMOS L=0.10u W=80.2u       ; M device
R109r 1 3 304                            ; R device
C109s 2 1 2.7u                           ; C device
M109t 3 1 2 0 PMOS L=0.10u W=8.0u
+ AD=14.94p AS=11.88p PD=23.7u PS=19.9u ; M device
M109u 2 0 1 3 NMOS L=0.18u W=93.7u       ; M device
M109v 2 3 1 0 NMOS L=0.25u W=91.0u       ; M device
M109w 3 2 1 0 PMOS L=0.10u W=46.1u       ; M device
C109x 1 0 0.6m                           ; C device
M109y 3 2 1 0 PMOS L=0.70u W=6.2u
+ AD=4.78p AS=2.11p PD=21.1u PS=23.4u ; M device
R109z 2 1 5.0M                           ; R device
C110a 0 2 2.5u                           ; C device
C110b 3 0 1.7m                           ; C device
M110c 2 0 1 3 PMOS L=0.25u W=26.7u AD=14.77p AS=45.53p PD=59.9u PS=58.4u ; M device
M110d 3 0 2 1 PMOS L=0.70u W=9.9u AD=6.59p AS=1.47p PD=28.9u PS=31.0u ; M device
M110e 2 1 3 0 PMOS L=0.70u W=86.2u       ; M device
C110f 3 2 7.0m                           ; C device
M110g 3 2 0 1 NMOS L=0.25u W=69.6u AD=67.03p AS=70.21p PD=182.5u PS=148.7u ; M device
C110h 3 1 333p                           ; C device
C110i 1 0 6.2u                           ; C device
C110j 3 0 5n                             ; C device
M110k 2 1 3 0 PMOS L=0.13u W=22.5u AD=13.69p AS=43.20p PD=78.9u PS=51.0u ; M device
C110l 0 2 8.5u                           ; C device
M110m 0 1 3 2 NMOS L=0.18u W=50.9u AD=49.54p AS=93.12p PD=159.0u PS=116.3u ; M device
R110n 2 3 9.4M                           ; R device
R110o 1 3 549                            ; R device
R110p 3 2 1.4M                           ; R device
C110q 0 2 55n                            ; C device
C110r 3 0 85n                            ; C device
M110s 3 2 0 1 PMOS L=0.50u W=5.8u        ; M device
R110t 2 3 924                            ; R device
C110u 0 1 8.3m                           ; C device
R110v 2 3 92k                            ; R device
C110w 1 3 17n                            ; C device
R110x 1 2 1.5M                           ; R device
C110y 1 2 97n                            ; C device
C110z 1 2 14n                            ; C device
M111a 0 3 1 2 NMOS L=0.50u W=69.7u       ; M device
R111b 3 1 7.5M                           ; R device
M111c 0 1 2 3 NMOS L=0.50u W=6.9u        ; M device
R111d 0 2 0.7M                           ; R device
M111e 0 3 2 1 PMOS L=0.13u W=98.6u       ; M device
M111f 0 1 3 2 NMOS L=1.00u W=53.0u AD=48.70p AS=97.55p PD=140.6u PS=185.5u ; M device
M111g 0 2 3 1 NMOS L=0.18u W=62.8u       ; M device
M111h 1 0 2 3 NMOS L=0.35u W=65.0u AD=36.36p AS=113.12p PD=171.4u PS=215.8u ; M device
R111i 3 2 27k                            ; R device
M111j 3 0 1 2 NMOS L=0.10u W=15.7u
+ AD=2.01p AS=13.10p PD=55.6u PS=34.4u ; M device
C111k 0 1 9.0m                           ; C device
M111l 0 1 2 3 NMOS L=0.10u W=96.0u AD=140.23p AS=171.30p PD=268.0u PS=375.2u ; M device
C111m 3 1 45n                            ; C device
R111n 1 0 579                            ; R device
C111o 0 2 0.6m                           ; C device
C111p 2 1 663p                           ; C device
R111q 2 1 34k                            ; R device
M111r 1 2 3 0 PMOS L=0.13u W=16.0u       ; M device
R111s 3 2 6.5M                           ; R device
M111t 1 0 3 2 PMOS L=0.35u W=32.7u       ; M device
M111u 2 3 0 1 NMOS L=0.13u W=34.7u       ; M device
R111v 0 1 1.1M                           ; R device
M111w 3 1 2 0 NMOS L=0.35u W=28.5u       ; M device
R111x 0 3 68                             ; R device
C111y 0 1 49n                            ; C device
C111z 0 3 6.9m                           ; C device
M112a 0 2 1 3 NMOS L=0.25u W=62.1u AD=87.68p AS=28.79p PD=175.0u PS=189.4u ; M device
C112b 0 3 8.1m                           ; C device
R112c 0 3 64k                            ; R device
R112d 3 0 923                            ; R device
C112e 3 2 6.9u                           ; C device
C112f 3 1 33n                            ; C device
M112g 3 1 2 0 PMOS L=0.25u W=3.1u
+ AD=0.33p AS=4.55p PD=12.5u PS=8.9u ; M device
M112h 0 1 2 3 PMOS L=0.70u W=58.9u
+ AD=86.66p AS=25.52p PD=158.8u PS=146.6u ; M device
R112i 3 1 9.9M                           ; R device
R112j 0 2 2.5M                           ; R device
R112k 2 3 1.3M                           ; R device
C112l 1 0 479p                           ; C device
C112m 0 3 4.6m                           ; C device
R112n 3 0 227                            ; R device
M112o 0 3 2 1 PMOS L=0.35u W=30.8u
+ AD=12.53p AS=52.59p PD=110.1u PS=68.0u ; M device
R112p 3 0 86k                            ; R device
R112q 0 2 66k                            ; R device
C112r 0 3 83n                            ; C device
M112s 2 0 3 1 NMOS L=0.13u W=96.2u
+ AD=174.78p AS=27.81p PD=268.7u PS=334.4u ; M device
M112t 0 2 1 3 PMOS L=0.18u W=66.8u       ; M device
R112u 1 0 209                            ; R device
R112v 3 1 82k                            ; R device
C112w 2 3 1.5m                           ; C device
C112x 1 2 9.7m                           ; C device
M112y 3 2 1 0 PMOS L=0.70u W=3.5u        ; M device
M112z 1 0 3 2 PMOS L=0.25u W=74.1u       ; M device
C113a 0 2 2.8u                           ; C device
M113b 0 1 2 3 NMOS L=0.50u W=90.4u       ; M device
C113c 3 2 92n                            ; C device
R113d 1 2 9.9M                           ; R device
M113e 2 0 3 1 PMOS L=0.50u W=59.6u       ; M device
M113f 2 1 3 0 NMOS L=1.00u W=56.3u       ; M device
M113g 1 0 2 3 PMOS L=1.00u W=18.2u
+ AD=6.33p AS=10.19p PD=45.1u PS=62.8u ; M device
C113h 3 2 99n                            ; C device
C113i 1 0 4.8m                           ; C device
R113j 2 0 4.1M                           ; R device
M113k 1 3 2 0 PMOS L=0.10u W=94.5u       ; M device
C113l 2 0 1.5m                           ; C device
C113m 3 2 16n                            ; C device
C113n 1 0 4.1u                           ; C device
M113o 1 0 3 2 PMOS L=0.10u W=9.4u        ; M device
M113p 1 3 2 0 NMOS L=0.18u W=75.2u       ; M device
M113q 2 0 1 3 PMOS L=0.18u W=34.1u       ; M device
C113r 3 0 578p                           ; C device
M113s 0 1 3 2 NMOS L=0.35u W=94.8u AD=43.29p AS=32.71p PD=222.2u PS=355.8u ; M device
M113t 1 3 0 2 NMOS L=0.70u W=35.9u
+ AD=30.00p AS=42.44p PD=122.2u PS=101.4u ; M device
R113u 0 3 3.4M                           ; R device
M113v 2 0 1 3 PMOS L=0.70u W=77.2u
+ AD=11.36p AS=34.55p PD=267.7u PS=223.6u ; M device
R113w 3 2 21k                            ; R device
M113x 3 0 1 2 PMOS L=0.35u W=84.6u
+ AD=64.59p AS=32.47p PD=250.0u PS=175.8u ; M device
M113y 1 3 0 2 NMOS L=1.00u W=7.9u        ; M device
R113z 2 0 192                            ; R device
R114a 0 1 401                            ; R device
C114b 0 3 3n                             ; C device
M114c 1 3 0 2 NMOS L=0.70u W=21.2u
+ AD=7.85p AS=37.64p PD=49.7u PS=52.2u ; M device
C114d 2 3 871p                           ; C device
M114e 1 2 3 0 NMOS L=0.10u W=48.7u       ; M device
C114f 0 1 6.4u                           ; C device
C114g 3 2 25n                            ; C device
M114h 1 0 3 2 NMOS L=0.10u W=35.6u       ; M device
C114i 3 1 63n                            ; C device
C114j 2 3 5.7u                           ; C device
R114k 3 0 96                             ; R device
R114l 3 1 5.3M                           ; R device
M114m 2 3 1 0 PMOS L=0.70u W=62.7u
+ AD=26.75p AS=60.92p PD=136.6u PS=166.1u ; M device
C114n 3 1 8.5u                           ; C device
C114o 1 3 3.4m                           ; C device
R114p 2 3 9.5M                           ; R device
C114q 0 1 0.2u                           ; C device
M114r 1 2 3 0 NMOS L=0.50u W=79.8u
+ AD=138.61p AS=123.98p PD=291.1u PS=262.7u ; M device
M114s 1 0 3 2 NMOS L=0.10u W=60.0u       ; M device
R114t 3 2 5.3M                           ; R device
C114u 2 0 0.4u                           ; C device
R114v 2 3 42k                            ; R device
M114w 1 3 2 0 PMOS L=0.25u W=14.5u AD=21.93p AS=27.03p PD=43.7u PS=31.0u ; M device
M114x 2 0 1 3 NMOS L=0.13u W=48.4u
+ AD=39.08p AS=26.20p PD=188.5u PS=129.5u ; M device
M114y 2 3 1 0 PMOS L=0.50u W=8.5u AD=7.60p AS=11.92p PD=33.5u PS=30.5u ; M device
M114z 0 1 2 3 PMOS L=0.70u W=53.9u
+ AD=71.85p AS=90.30p PD=143.1u PS=119.1u ; M device
M115a 2 3 1 0 NMOS L=0.25u W=49.2u       ; M device
R115b 0 2 33k                            ; R device
C115c 1 3 8.9m                           ; C device
R115d 2 0 8.4M                           ; R device
C115e 0 2 1.2m                           ; C device
C115f 0 1 7.8u                           ; C device
M115g 3 1 0 2 NMOS L=0.13u W=36.4u       ; M device
C115h 2 0 0.6m                           ; C device
R115i 3 0 37k                            ; R device
C115j 1 0 7.9m                           ; C device
M115k 3 0 2 1 PMOS L=0.70u W=21.6u
+ AD=21.32p AS=19.62p PD=51.3u PS=53.8u ; M device
R115l 3 0 75k                            ; R device
R115m 1 3 2.5M                           ; R device
R115n 0 2 428                            ; R device
M115o 1 0 3 2 PMOS L=0.35u W=92.2u
+ AD=82.03p AS=99.51p PD=194.1u PS=225.4u ; M device
R115p 3 2 59k                            ; R device
C115q 2 3 8.2m                           ; C device
R115r 3 1 682                            ; R device
R115s 0 3 69                             ; R device
C115t 1 0 4.0m                           ; C device
C115u 3 0 5.1m                           ; C device
C115v 2 1 1.2m                           ; C device
M115w 1 3 2 0 PMOS L=0.13u W=87.2u       ; M device
R115x 3 2 80k                            ; R device
R115y 1 3 43k                            ; R device
R115z 1 2 172                            ; R device
R116a 2 0 911                            ; R device
C116b 3 2 47n                            ; C device
R116c 1 0 828                            ; R device
M116d 3 2 1 0 PMOS L=0.18u W=15.9u AD=29.37p AS=22.08p PD=55.4u PS=54.2u ; M device
R116e 1 2 267                            ; R device
R116f 1 3 128                            ; R device
R116g 1 3 25k                            ; R device
R116h 0 2 66k                            ; R device
R116i 3 1 6.1M                           ; R device
M116j 1 2 0 3 NMOS L=0.25u W=67.2u
+ AD=117.73p AS=51.66p PD=137.7u PS=224.2u ; M device
M116k 0 1 3 2 PMOS L=0.25u W=9.4u AD=9.31p AS=16.03p PD=26.9u PS=30.7u ; M device
M116l 1 3 0 2 NMOS L=0.13u W=8.7u        ; M device
R116m 2 0 329                            ; R device
C116n 0 1 89n                            ; C device
M116o 2 3 1 0 PMOS L=0.50u W=29.2u AD=4.82p AS=13.48p PD=90.6u PS=105.8u ; M device
R116p 3 0 274                            ; R device
C116q 2 1 4.2m                           ; C device
C116r 1 0 87p                            ; C device
R116s 2 1 775                            ; R device
R116t 2 3 50k                            ; R device
R116u 0 2 2.2M                           ; R device
M116v 1 0 2 3 PMOS L=0.13u W=66.1u AD=103.63p AS=78.18p PD=143.6u PS=202.2u ; M device
R116w 0 1 46k                            ; R device
C116x 2 0 6.2u                           ; C device
R116y 3 0 0.3M                           ; R device
M116z 0 1 2 3 PMOS L=0.10u W=25.9u AD=10.63p AS=26.86p PD=81.8u PS=70.5u ; M device
M117a 2 0 3 1 PMOS L=0.13u W=65.1u       ; M device
R117b 2 3 1.3M                           ; R device
M117c 3 2 1 0 PMOS L=0.70u W=45.2u       ; M device
M117d 1 3 0 2 NMOS L=0.70u W=41.5u       ; M device
R117e 1 2 0.8M                           ; R device
C117f 1 0 63n                            ; C device
C117g 3 0 753p                           ; C device
R117h 3 0 742                            ; R device
R117i 1 0 506                            ; R device
C117j 1 3 449p                           ; C device
R117k 1 2 3.4M                           ; R device
R117l 0 1 45k                            ; R device
C117m 0 2 116p                           ; C device
M117n 2 1 0 3 PMOS L=0.13u W=37.2u       ; M device
R117o 1 0 6.7M                           ; R device
C117p 2 0 6.7u                           ; C device
M117q 3 0 1 2 NMOS L=0.18u W=54.8u       ; M device
C117r 1 2 5.5u                           ; C device
M117s 3 2 1 0 PMOS L=0.13u W=77.7u
+ AD=111.69p AS=45.13p PD=193.9u PS=161.1u ; M device
R117t 0 2 67k                            ; R device
M117u 1 3 0 2 PMOS L=0.13u W=56.9u AD=23.26p AS=92.65p PD=160.5u PS=186.6u ; M device
M117v 1 2 0 3 NMOS L=0.70u W=94.7u       ; M device
M117w 0 3 1 2 PMOS L=0.50u W=30.1u AD=53.16p AS=12.19p PD=67.0u PS=78.9u ; M device
R117x 1 2 6.9M                           ; R device
C117y 2 0 346p                           ; C device
C117z 0 3 64n                            ; C device
M118a 3 0 1 2 PMOS L=1.00u W=12.0u       ; M device
C118b 2 3 89n                            ; C device
R118c 3 2 81k                            ; R device
C118d 3 2 2.8m                           ; C device
C118e 3 1 872p                           ; C device
M118f 1 0 3 2 PMOS L=0.13u W=12.5u AD=11.92p AS=6.55p PD=28.3u PS=46.0u ; M device
R118g 3 2 442                            ; R device
R118h 3 0 1.4M                           ; R device
M118i 1 2 3 0 NMOS L=0.10u W=79.0u       ; M device
R118j 0 1 3.0M                           ; R device
C118k 1 3 0.8m                           ; C device
C118l 2 1 635p                           ; C device
R118m 2 3 17k                            ; R device
C118n 3 0 995p                           ; C device
C118o 0 2 8.6m                           ; C device
M118p 2 0 3 1 NMOS L=0.25u W=20.6u AD=30.98p AS=5.89p PD=76.4u PS=58.6u ; M device
C118q 3 2 87n                            ; C device
C118r 0 2 82n                            ; C device
R118s 2 3 25k                            ; R device
C118t 1 3 16n                            ; C device
R118u 3 1 6k                             ; R device
C118v 1 3 9n                             ; C device
M118w 0 2 3 1 PMOS L=0.50u W=70.7u
+ AD=86.89p AS=73.92p PD=175.2u PS=279.5u ; M device
C118x 1 3 3.9u                           ; C device
R118y 2 0 278                            ; R device
C118z 3 2 9.4m                           ; C device
C119a 3 2 4.0m                           ; C device
R119b 1 0 23k                            ; R device
M119c 1 0 3 2 PMOS L=1.00u W=72.8u AD=65.99p AS=10.90p PD=225.1u PS=151.6u ; M device
C119d 0 2 1.7u                           ; C device
R119e 2 0 6.4M                           ; R device
R119f 3 0 60k                            ; R device
C119g 2 1 1.5u                           ; C device
R119h 3 0 218                            ; R device
M119i 0 1 2 3 NMOS L=0.50u W=89.4u       ; M device
C119j 2 3 768p                           ; C device
R119k 0 1 7k                             ; R device
R119l 2 0 93k                            ; R device
C119m 2 0 853p                           ; C device
C119n 1 3 8.0m                           ; C device
R119o 3 1 5k                             ; R device
C119p 3 0 23n                            ; C device
C119q 1 3 546p                           ; C device
M119r 2 1 0 3 PMOS L=0.25u W=68.0u       ; M device
C119s 3 2 6.2m                           ; C device
M119t 0 3 1 2 PMOS L=0.70u W=22.2u       ; M device
R119u 1 0 691                            ; R device
M119v 2 0 3 1 PMOS L=0.25u W=81.6u
+ AD=148.00p AS=80.80p PD=318.0u PS=285.6u ; M device
C119w 2 3 87p                            ; C device
M119x 3 2 1 0 PMOS L=0.35u W=56.5u
+ AD=88.60p AS=64.36p PD=162.1u PS=197.8u ; M device
R119y 3 2 225                            ; R device
C119z 0 2 7.6m                           ; C device
C120a 0 1 0.3u                           ; C device
R120b 1 3 48                             ; R device
M120c 2 3 1 0 PMOS L=0.35u W=22.0u       ; M device
R120d 2 0 40k                            ; R device
R120e 0 2 708                            ; R device
C120f 1 0 926p                           ; C device
C120g 2 3 95n                            ; C device
R120h 1 3 42k                            ; R device
M120i 1 2 0 3 PMOS L=0.10u W=83.9u       ; M device
M120j 2 0 1 3 PMOS L=0.35u W=16.7u       ; M device
M120k 3 1 2 0 PMOS L=0.18u W=76.2u       ; M device
C120l 0 2 94n                            ; C device
C120m 2 3 39p                            ; C device
M120n 1 3 0 2 PMOS L=0.25u W=42.2u       ; M device
R120o 0 1 1k                             ; R device
C120p 3 0 726p                           ; C device
M120q 1 2 3 0 PMOS L=0.50u W=18.7u
+ AD=16.84p AS=32.76p PD=47.7u PS=49.1u ; M device
R120r 3 1 3.2M                           ; R device
M120s 2 1 0 3 PMOS L=0.70u W=99.6u       ; M device
R120t 3 1 765                            ; R device
M120u 0 2 3 1 PMOS L=0.18u W=46.8u       ; M device
C120v 1 3 0.2m                           ; C device
C120w 1 3 7.4m                           ; C device
C120x 0 2 0.2m                           ; C device
C120y 3 0 173p                           ; C device
C120z 3 2 8.2u                           ; C device
M121a 0 2 1 3 NMOS L=0.35u W=55.6u       ; M device
M121b 3 0 2 1 NMOS L=1.00u W=31.9u       ; M device
C121c 2 0 4.1m                           ; C device
R121d 0 1 903                            ; R device
R121e 0 3 2.8M                           ; R device
M121f 1 3 0 2 PMOS L=0.13u W=15.4u       ; M device
C121g 3 2 4.4u                           ; C device
C121h 0 3 2.8m                           ; C device
R121i 3 1 265                            ; R device
C121j 2 3 2.6u                           ; C device
M121k 3 0 2 1 NMOS L=0.50u W=9.1u        ; M device
R121l 0 2 468                            ; R device
R121m 0 1 8.4M                           ; R device
M121n 0 1 3 2 NMOS L=0.10u W=43.5u       ; M device
R121o 1 3 483                            ; R device
M121p 3 0 1 2 NMOS L=0.35u W=1.9u
+ AD=1.82p AS=2.51p PD=5.8u PS=6.0u ; M device
R121q 3 2 6.8M                           ; R device
C121r 2 3 800p                           ; C device
R121s 2 3 5.7M                           ; R device
M121t 1 3 2 0 NMOS L=0.50u W=29.1u       ; M device
M121u 2 3 1 0 PMOS L=1.00u W=26.0u       ; M device
M121v 1 2 0 3 NMOS L=1.00u W=61.0u       ; M device
C121w 0 2 2.4u                           ; C device
C121x 3 2 784p                           ; C device
R121y 2 1 32k                            ; R device
M121z 3 1 0 2 NMOS L=0.10u W=36.9u AD=50.18p AS=65.91p PD=134.9u PS=110.4u ; M device
R122a 0 3 60k                            ; R device
M122b 0 1 3 2 NMOS L=0.35u W=46.8u       ; M device
M122c 0 1 2 3 PMOS L=0.18u W=28.1u       ; M device
C122d 3 1 1.0u                           ; C device
M122e 1 0 2 3 PMOS L=0.50u W=27.6u AD=37.70p AS=10.99p PD=59.2u PS=58.9u ; M device
R122f 1 2 4k                             ; R device
R122g 3 1 288                            ; R device
C122h 3 1 3.6m                           ; C device
R122i 1 2 17k                            ; R device
M122j 0 3 2 1 PMOS L=0.25u W=15.4u       ; M device
M122k 1 0 2 3 PMOS L=0.70u W=28.6u       ; M device
R122l 0 1 49k                            ; R device
M122m 0 3 2 1 NMOS L=0.13u W=22.7u
+ AD=9.28p AS=13.06p PD=81.7u PS=48.1u ; M device
C122n 2 3 5.5u                           ; C device
C122o 1 3 3.5m                           ; C device
C122p 3 0 9.5u                           ; C device
C122q 2 1 36n                            ; C device
M122r 2 0 1 3 NMOS L=0.18u W=5.5u        ; M device
M122s 2 0 1 3 NMOS L=0.18u W=15.7u AD=23.18p AS=23.82p PD=39.0u PS=48.9u ; M device
C122t 1 0 100n                           ; C device
C122u 2 1 9.3u                           ; C device
M122v 0 2 3 1 NMOS L=0.70u W=84.7u       ; M device
R122w 2 3 100k                           ; R device
M122x 1 0 2 3 PMOS L=0.35u W=19.0u       ; M device
R122y 2 3 13                             ; R device
R122z 1 0 59k                            ; R device
R123a 2 1 14k                            ; R device
M123b 0 3 2 1 PMOS L=0.10u W=62.2u AD=101.22p AS=8.33p PD=153.6u PS=125.9u ; M device
R123c 0 3 1k                             ; R device
R123d 1 3 13k                            ; R device
R123e 0 3 25k                            ; R device
M123f 0 2 3 1 PMOS L=0.25u W=12.8u AD=6.65p AS=18.78p PD=40.5u PS=39.2u ; M device
M123g 2 1 0 3 NMOS L=0.10u W=94.9u AD=134.61p AS=186.01p PD=220.5u PS=349.4u ; M device
M123h 2 0 1 3 NMOS L=0.70u W=56.7u
+ AD=58.00p AS=35.41p PD=207.2u PS=212.9u ; M device
C123i 2 3 8.3u                           ; C device
M123j 2 0 1 3 NMOS L=0.70u W=58.9u       ; M device
M123k 2 3 0 1 PMOS L=1.00u W=30.0u       ; M device
M123l 1 2 0 3 PMOS L=0.50u W=24.9u       ; M device
M123m 0 3 2 1 PMOS L=0.70u W=42.7u       ; M device
R123n 1 2 316                            ; R device
R123o 1 3 51k                            ; R device
R123p 0 2 23k                            ; R device
C123q 2 0 936p                           ; C device
C123r 2 3 0.8u                           ; C device
M123s 2 1 3 0 NMOS L=0.35u W=39.6u AD=52.52p AS=74.81p PD=124.7u PS=95.6u ; M device
R123t 1 3 923                            ; R device
R123u 1 0 6.9M                           ; R device
R123v 1 3 3k                             ; R device
M123w 2 1 0 3 NMOS L=0.25u W=28.6u       ; M device
R123x 2 1 159                            ; R device
M123y 2 1 3 0 NMOS L=0.10u W=32.0u       ; M device
R123z 3 2 4.5M                           ; R device
C124a 1 2 20n                            ; C device
C124b 0 1 5n                             ; C device
R124c 0 1 8.9M                           ; R device
M124d 1 0 3 2 NMOS L=1.00u W=97.9u AD=124.45p AS=67.52p PD=197.1u PS=346.0u ; M device
M124e 3 0 1 2 NMOS L=0.13u W=54.7u AD=84.37p AS=50.96p PD=115.2u PS=121.2u ; M device
R124f 3 1 57k                            ; R device
M124g 2 3 0 1 PMOS L=0.25u W=73.1u       ; M device
C124h 0 3 8.6m                           ; C device
M124i 3 1 2 0 PMOS L=0.18u W=10.2u       ; M device
R124j 2 0 505                            ; R device
C124k 3 2 5.3u                           ; C device
R124l 1 3 98                             ; R device
M124m 2 3 0 1 NMOS L=0.25u W=1.9u
+ AD=0.45p AS=0.25p PD=4.5u PS=6.5u ; M device
R124n 1 0 538                            ; R device
C124o 2 0 72n                            ; C device
C124p 2 1 10.0m                          ; C device
M124q 1 3 0 2 PMOS L=0.10u W=86.2u
+ AD=155.75p AS=147.19p PD=323.1u PS=241.9u ; M device
M124r 2 0 1 3 PMOS L=0.25u W=73.9u       ; M device
M124s 1 2 3 0 PMOS L=0.35u W=25.6u AD=43.19p AS=44.50p PD=56.3u PS=81.8u ; M device
M124t 2 3 1 0 NMOS L=1.00u W=12.5u       ; M device
R124u 3 0 0.2M                           ; R device
M124v 2 0 1 3 NMOS L=0.13u W=65.1u       ; M device
M124w 2 3 0 1 PMOS L=0.35u W=72.7u AD=133.96p AS=138.72p PD=234.7u PS=261.7u ; M device
C124x 2 3 7.6m                           ; C device
C124y 0 3 990p                           ; C device
M124z 0 2 1 3 PMOS L=0.50u W=86.9u       ; M device
M125a 3 1 2 0 PMOS L=0.10u W=0.5u AD=0.43p AS=0.28p PD=1.8u PS=1.1u ; M device
R125b 3 1 4.8M                           ; R device
M125c 3 0 2 1 NMOS L=0.25u W=33.2u       ; M device
R125d 1 2 554                            ; R device
R125e 0 3 68k                            ; R device
M125f 0 3 1 2 PMOS L=0.35u W=78.6u       ; M device
M125g 2 1 0 3 PMOS L=0.25u W=96.3u
+ AD=49.55p AS=118.15p PD=320.0u PS=329.8u ; M device
R125h 2 0 931                            ; R device
C125i 0 2 711p                           ; C device
C125j 3 0 57n                            ; C device
R125k 3 2 85k                            ; R device
R125l 1 2 809                            ; R device
M125m 3 2 0 1 PMOS L=0.18u W=46.4u       ; M device
C125n 0 2 74n                            ; C device
M125o 1 0 2 3 NMOS L=0.18u W=73.7u       ; M device
M125p 0 1 2 3 PMOS L=0.18u W=41.4u
+ AD=43.53p AS=21.90p PD=130.6u PS=157.3u ; M device
R125q 1 2 5k                             ; R device
M125r 3 0 1 2 PMOS L=0.18u W=10.6u       ; M device
R125s 2 3 3.9M                           ; R device
R125t 1 2 1.8M                           ; R device
C125u 1 2 15n                            ; C device
C125v 3 2 550p                           ; C device
M125w 1 2 3 0 PMOS L=0.25u W=79.8u AD=110.93p AS=46.46p PD=217.5u PS=299.2u ; M device
M125x 2 1 3 0 PMOS L=0.70u W=78.7u       ; M device
C125y 2 0 2.2u                           ; C device
C125z 0 3 13p                            ; C device
M126a 3 2 1 0 PMOS L=0.18u W=43.6u
+ AD=37.28p AS=85.84p PD=119.9u PS=119.6u ; M device
M126b 1 2 3 0 PMOS L=0.18u W=91.5u
+ AD=15.19p AS=65.31p PD=270.0u PS=245.8u ; M device
C126c 3 2 66n                            ; C device
M126d 0 1 2 3 PMOS L=0.18u W=52.0u
+ AD=81.08p AS=37.90p PD=182.1u PS=199.8u ; M device
M126e 1 0 2 3 NMOS L=0.35u W=73.0u       ; M device
C126f 0 1 496p                           ; C device
R126g 1 3 15k                            ; R device
R126h 0 3 9.9M                           ; R device
C126i 0 1 5n                             ; C device
C126j 3 1 802p                           ; C device
M126k 0 3 1 2 NMOS L=0.70u W=21.0u       ; M device
C126l 1 3 3.4m                           ; C device
R126m 2 1 73k                            ; R device
M126n 2 0 1 3 NMOS L=0.25u W=4.6u
+ AD=7.18p AS=2.58p PD=15.9u PS=9.8u ; M device
M126o 1 3 2 0 NMOS L=0.13u W=40.0u       ; M device
R126p 1 0 802                            ; R device
R126q 0 3 55k                            ; R device
C126r 3 2 4.7m                           ; C device
R126s 0 1 958                            ; R device
M126t 2 1 0 3 NMOS L=0.25u W=99.8u       ; M device
M126u 2 0 3 1 NMOS L=0.50u W=88.3u AD=79.59p AS=144.52p PD=193.5u PS=256.9u ; M device
M126v 0 3 2 1 PMOS L=0.10u W=75.0u       ; M device
R126w 3 2 1.0M                           ; R device
C126x 2 3 366p                           ; C device
R126y 0 2 441                            ; R device
M126z 2 1 0 3 PMOS L=0.25u W=52.2u       ; M device
C127a 0 3 21n                            ; C device
M127b 3 0 2 1 NMOS L=0.25u W=79.3u       ; M device
R127c 2 3 6.8M                           ; R device
C127d 3 0 90n                            ; C device
M127e 2 0 1 3 NMOS L=0.13u W=39.9u AD=32.80p AS=64.68p PD=112.2u PS=101.2u ; M device
R127f 0 1 726                            ; R device
R127g 3 0 73k                            ; R device
C127h 1 3 17n                            ; C device
M127i 2 0 1 3 NMOS L=0.70u W=85.1u AD=151.81p AS=42.73p PD=282.1u PS=192.9u ; M device
C127j 2 0 577p                           ; C device
C127k 0 3 55n                            ; C device
C127l 2 0 513p                           ; C device
R127m 2 3 206                            ; R device
C127n 3 2 891p                           ; C device
M127o 2 0 3 1 PMOS L=0.25u W=61.7u
+ AD=118.94p AS=118.94p PD=138.9u PS=189.9u ; M device
R127p 1 2 301                            ; R device
R127q 1 0 6.6M                           ; R device
C127r 1 0 208p                           ; C device
R127s 2 1 816                            ; R device
C127t 2 0 5.6m                           ; C device
C127u 2 0 70n                            ; C device
R127v 0 3 648                            ; R device
C127w 0 3 3.4m                           ; C device
C127x 0 1 5.3m                           ; C device
M127y 1 0 3 2 NMOS L=0.35u W=38.9u AD=55.26p AS=49.33p PD=130.1u PS=105.4u ; M device
M127z 3 2 1 0 NMOS L=0.25u W=56.0u       ; M device
R128a 1 2 0.2M                           ; R device
M128b 2 3 1 0 PMOS L=0.13u W=49.2u       ; M device
R128c 0 3 282                            ; R device
C128d 2 3 103p                           ; C device
R128e 0 2 406                            ; R device
R128f 2 3 29                             ; R device
C128g 0 3 192p                           ; C device
M128h 3 2 1 0 PMOS L=0.18u W=32.5u       ; M device
M128i 2 0 1 3 NMOS L=1.00u W=77.2u       ; M device
R128j 2 0 48                             ; R device
R128k 0 1 79k                            ; R device
C128l 1 2 4.5m                           ; C device
C128m 3 1 8.6m                           ; C device
R128n 2 1 396                            ; R device
M128o 2 1 0 3 PMOS L=0.70u W=91.3u       ; M device
R128p 3 2 71                             ; R device
C128q 0 1 0.6u                           ; C device
C128r 0 2 666p                           ; C device
M128s 1 2 0 3 NMOS L=1.00u W=64.8u       ; M device
R128t 2 0 5.9M                           ; R device
C128u 3 2 9.6m                           ; C device
C128v 3 1 3.0u                           ; C device
C128w 1 0 12p                            ; C device
C128x 0 3 6.7u                           ; C device
M128y 0 3 1 2 PMOS L=0.10u W=94.5u AD=182.63p AS=176.95p PD=328.6u PS=356.3u ; M device
R128z 3 2 283                            ; R device
R129a 3 1 82k                            ; R device
C129b 2 3 37n                            ; C device
M129c 2 0 3 1 PMOS L=1.00u W=75.3u
+ AD=111.11p AS=100.70p PD=300.6u PS=189.0u ; M device
M129d 2 3 1 0 PMOS L=0.10u W=6.8u        ; M device
C129e 3 1 930p                           ; C device
M129f 0 1 3 2 NMOS L=0.70u W=12.6u AD=19.12p AS=23.76p PD=28.7u PS=35.1u ; M device
C129g 1 3 3.4u                           ; C device
C129h 2 1 443p                           ; C device
R129i 1 0 20k                            ; R device
C129j 2 0 9.7m                           ; C device
R129k 1 2 762                            ; R device
R129l 2 3 409                            ; R device
M129m 1 0 2 3 PMOS L=0.13u W=52.3u       ; M device
R129n 1 3 971                            ; R device
C129o 2 1 698p                           ; C device
R129p 3 1 811                            ; R device
M129q 1 2 0 3 PMOS L=0.13u W=23.3u       ; M device
C129r 2 1 333p                           ; C device
R129s 0 1 24k                            ; R device
C129t 3 2 77n                            ; C device
C129u 3 2 28n                            ; C device
M129v 3 0 1 2 PMOS L=0.13u W=34.9u       ; M device
M129w 3 2 1 0 NMOS L=0.25u W=98.6u
+ AD=110.57p AS=65.81p PD=249.7u PS=199.6u ; M device
M129x 3 0 2 1 PMOS L=0.10u W=7.5u        ; M device
R129y 0 1 690                            ; R device
C129z 2 0 0.4m                           ; C device
M130a 0 1 3 2 PMOS L=0.18u W=23.1u       ; M device
R130b 0 2 54k                            ; R device
M130c 3 2 0 1 NMOS L=0.10u W=36.8u       ; M device
M130d 1 2 0 3 NMOS L=0.13u W=6.5u
+ AD=12.27p AS=4.13p PD=23.2u PS=17.0u ; M device
C130e 1 2 514p                           ; C device
R130f 1 3 73                             ; R device
M130g 3 1 0 2 NMOS L=0.50u W=14.1u
+ AD=9.15p AS=21.48p PD=46.5u PS=31.7u ; M device
M130h 2 0 1 3 NMOS L=0.50u W=78.4u AD=96.06p AS=21.03p PD=180.6u PS=219.5u ; M device
C130i 1 3 8.1u                           ; C device
R130j 0 3 68k                            ; R device
R130k 0 3 2.8M                           ; R device
R130l 3 0 5.3M                           ; R device
R130m 1 2 24                             ; R device
C130n 0 2 17n                            ; C device
C130o 0 2 0.6m                           ; C device
R130p 2 3 269                            ; R device
C130q 0 1 890p                           ; C device
M130r 1 2 3 0 PMOS L=0.35u W=22.2u       ; M device
M130s 2 0 1 3 PMOS L=0.10u W=38.0u
+ AD=6.75p AS=29.91p PD=138.0u PS=144.6u ; M device
C130t 1 2 4.0u                           ; C device
C130u 3 0 5.7m                           ; C device
M130v 0 1 3 2 NMOS L=0.70u W=72.2u       ; M device
R130w 0 2 456                            ; R device
R130x 1 3 8.9M                           ; R device
C130y 0 3 9.5u                           ; C device
C130z 2 3 0.7u                           ; C device
M131a 1 3 0 2 PMOS L=1.00u W=4.6u AD=5.09p AS=4.90p PD=17.4u PS=10.0u ; M device
M131b 1 2 0 3 PMOS L=0.35u W=15.5u       ; M device
R131c 1 3 370                            ; R device
M131d 1 3 0 2 NMOS L=0.25u W=96.9u AD=15.54p AS=52.76p PD=289.1u PS=294.2u ; M device
M131e 0 3 1 2 PMOS L=0.70u W=82.9u
+ AD=87.32p AS=43.58p PD=294.6u PS=190.3u ; M device
C131f 0 2 91n                            ; C device
R131g 3 2 51k                            ; R device
C131h 1 0 3.4m                           ; C device
M131i 3 1 0 2 PMOS L=0.13u W=87.2u       ; M device
C131j 1 0 4.8m                           ; C device
C131k 3 0 59n                            ; C device
M131l 3 1 0 2 PMOS L=0.13u W=59.5u       ; M device
R131m 0 3 7k                             ; R device
R131n 1 2 1.4M                           ; R device
R131o 3 0 15k                            ; R device
C131p 2 0 6.9m                           ; C device
R131q 0 1 71k                            ; R device
M131r 3 2 1 0 NMOS L=0.25u W=98.1u AD=129.65p AS=40.56p PD=223.1u PS=244.9u ; M device
M131s 2 1 3 0 PMOS L=0.35u W=47.6u AD=7.32p AS=33.06p PD=98.7u PS=138.7u ; M device
R131t 2 0 7.5M                           ; R device
M131u 2 3 0 1 PMOS L=0.50u W=46.6u
+ AD=57.88p AS=12.04p PD=179.4u PS=159.5u ; M device
M131v 2 0 1 3 PMOS L=0.50u W=21.7u
+ AD=19.15p AS=26.85p PD=56.0u PS=85.0u ; M device
M131w 3 1 2 0 PMOS L=0.25u W=83.0u
+ AD=91.11p AS=48.72p PD=270.4u PS=284.5u ; M device
R131x 2 3 97k                            ; R device
R131y 1 2 37k                            ; R device
M131z 3 2 1 0 NMOS L=0.25u W=84.0u       ; M device
R132a 2 3 81k                            ; R device
R132b 1 3 1.2M                           ; R device
M132c 3 2 0 1 PMOS L=0.70u W=36.7u       ; M device
M132d 0 1 2 3 NMOS L=1.00u W=94.9u AD=172.94p AS=164.91p PD=339.9u PS=304.8u ; M device
C132e 0 3 100p                           ; C device
M132f 2 0 3 1 NMOS L=1.00u W=52.8u       ; M device
M132g 1 2 3 0 PMOS L=0.10u W=23.8u       ; M device
R132h 3 0 0.7M                           ; R device
R132i 0 3 6k                             ; R device
R132j 3 1 4.9M                           ; R device
M132k 1 2 0 3 NMOS L=0.18u W=4.9u        ; M device
C132l 2 3 8.1u                           ; C device
R132m 0 3 159                            ; R device
M132n 1 2 0 3 PMOS L=0.25u W=40.5u       ; M device
C132o 3 0 3.0u                           ; C device
C132p 2 0 1.7u                           ; C device
C132q 1 2 55n                            ; C device
M132r 2 3 0 1 PMOS L=0.18u W=74.7u
+ AD=138.48p AS=118.57p PD=219.2u PS=255.5u ; M device
C132s 1 3 456p                           ; C device
C132t 3 1 7.6u                           ; C device
M132u 0 1 2 3 NMOS L=1.00u W=83.2u       ; M device
R132v 1 3 98k                            ; R device
R132w 3 2 74k                            ; R device
R132x 2 0 757                            ; R device
R132y 3 1 47k                            ; R device
C132z 1 2 4.8m                           ; C device
M133a 1 0 2 3 NMOS L=0.50u W=69.1u       ; M device
C133b 1 3 1n                             ; C device
M133c 3 0 1 2 NMOS L=0.25u W=96.5u       ; M device
M133d 0 1 2 3 NMOS L=0.35u W=58.9u
+ AD=8.52p AS=116.36p PD=189.7u PS=139.9u ; M device
R133e 3 1 89k                            ; R device
M133f 1 2 0 3 NMOS L=0.35u W=27.2u AD=37.79p AS=12.54p PD=96.1u PS=97.0u ; M device
M133g 1 2 0 3 PMOS L=0.35u W=10.0u       ; M device
R133h 1 0 3.0M                           ; R device
R133i 1 0 549                            ; R device
R133j 1 3 935                            ; R device
M133k 1 3 0 2 NMOS L=1.00u W=84.0u AD=134.13p AS=48.94p PD=313.2u PS=184.5u ; M device
M133l 1 0 3 2 PMOS L=0.10u W=89.7u       ; M device
M133m 2 0 3 1 PMOS L=0.10u W=97.0u AD=132.17p AS=92.58p PD=269.1u PS=313.8u ; M device
C133n 1 2 57n                            ; C device
M133o 1 2 3 0 NMOS L=0.50u W=19.3u       ; M device
M133p 2 3 1 0 PMOS L=0.25u W=95.1u AD=50.26p AS=106.35p PD=267.6u PS=319.4u ; M device
R133q 0 2 8.2M                           ; R device
C133r 1 3 9.1u                           ; C device
C133s 2 0 3.6u                           ; C device
C133t 3 1 5.8m                           ; C device
C133u 0 3 5.8m                           ; C device
C133v 1 0 2.2u                           ; C device
M133w 2 3 1 0 NMOS L=0.25u W=96.5u       ; M device
C133x 2 1 703p                           ; C device
R133y 3 2 97k                            ; R device
M133z 3 1 2 0 PMOS L=0.70u W=3.0u        ; M device
C134a 2 3 1.2m                           ; C device
M134b 3 1 0 2 NMOS L=0.25u W=71.0u
+ AD=23.75p AS=133.77p PD=283.0u PS=208.0u ; M device
R134c 2 1 924                            ; R device
M134d 3 1 0 2 PMOS L=0.25u W=15.4u       ; M device
C134e 3 0 0.9u                           ; C device
M134f 0 3 2 1 NMOS L=0.50u W=18.5u       ; M device
M134g 3 2 1 0 NMOS L=0.35u W=37.4u AD=18.41p AS=22.67p PD=100.8u PS=88.4u ; M device
M134h 2 3 1 0 NMOS L=0.50u W=41.3u
+ AD=70.98p AS=75.64p PD=157.8u PS=150.0u ; M device
C134i 3 0 67n                            ; C device
C134j 2 3 0.7u                           ; C device
M134k 0 1 2 3 PMOS L=0.10u W=77.7u       ; M device
C134l 2 0 80n                            ; C device
R134m 0 2 36k                            ; R device
M134n 0 3 1 2 PMOS L=0.70u W=43.6u
+ AD=7.08p AS=80.45p PD=149.1u PS=102.7u ; M device
M134o 2 0 3 1 PMOS L=1.00u W=96.6u AD=136.04p AS=141.56p PD=240.6u PS=252.4u ; M device
R134p 3 2 578                            ; R device
C134q 2 1 2.0m                           ; C device
M134r 0 2 1 3 PMOS L=0.10u W=74.0u       ; M device
C134s 1 2 3.1m                           ; C device
R134t 3 2 238                            ; R device
R134u 1 2 19k                            ; R device
C134v 3 2 4.4u                           ; C device
M134w 3 2 1 0 PMOS L=0.70u W=62.8u
+ AD=124.89p AS=60.85p PD=221.5u PS=158.6u ; M device
C134x 0 2 100n                           ; C device
C134y 1 2 4.0u                           ; C device
M134z 1 0 3 2 PMOS L=0.18u W=95.1u AD=91.53p AS=26.03p PD=322.5u PS=294.0u ; M device
C135a 1 2 574p                           ; C device
M135b 1 2 3 0 NMOS L=0.50u W=24.3u       ; M device
R135c 2 0 800                            ; R device
M135d 3 2 0 1 NMOS L=0.70u W=7.2u        ; M device
M135e 3 0 1 2 PMOS L=0.25u W=60.1u       ; M device
C135f 2 1 96n                            ; C device
R135g 0 3 2.7M                           ; R device
M135h 1 2 0 3 PMOS L=0.50u W=70.8u       ; M device
C135i 2 3 10.0m                          ; C device
C135j 1 0 50n                            ; C device
M135k 1 3 0 2 NMOS L=0.10u W=96.2u       ; M device
C135l 2 1 0.2u                           ; C device
M135m 1 0 2 3 PMOS L=0.35u W=86.4u AD=51.81p AS=170.62p PD=261.7u PS=332.2u ; M device
R135n 2 3 9.5M                           ; R device
M135o 0 3 1 2 NMOS L=0.35u W=44.9u       ; M device
C135p 2 0 548p                           ; C device
R135q 0 3 490                            ; R device
R135r 1 0 77k                            ; R device
C135s 3 2 687p                           ; C device
M135t 2 1 0 3 NMOS L=0.10u W=2.4u        ; M device
C135u 2 0 21p                            ; C device
M135v 0 3 2 1 PMOS L=0.70u W=58.1u       ; M device
M135w 1 2 3 0 NMOS L=0.50u W=62.2u       ; M device
R135x 2 1 100k                           ; R device
M135y 1 0 2 3 PMOS L=0.70u W=45.0u
+ AD=6.61p AS=10.13p PD=137.1u PS=95.2u ; M device
R135z 3 0 72k                            ; R device
R136a 3 0 79k                            ; R device
M136b 0 2 3 1 PMOS L=0.35u W=98.3u       ; M device
C136c 1 0 1.8u                           ; C device
M136d 0 2 3 1 NMOS L=0.70u W=56.1u       ; M device
M136e 1 0 2 3 PMOS L=1.00u W=28.5u
+ AD=32.43p AS=31.13p PD=80.6u PS=73.7u ; M device
M136f 1 2 0 3 PMOS L=0.18u W=90.7u       ; M device
M136g 0 3 1 2 PMOS L=1.00u W=74.2u       ; M device
R136h 3 1 0.7M                           ; R device
C136i 0 1 213p                           ; C device
R136j 0 1 2k                             ; R device
C136k 3 2 86n                            ; C device
C136l 2 0 86n                            ; C device
C136m 0 3 641p                           ; C device
C136n 0 1 8.0m                           ; C device
C136o 1 3 1.8m                           ; C device
R136p 0 2 808                            ; R device
C136q 0 2 648p                           ; C device
R136r 1 3 463                            ; R device
M136s 0 1 2 3 PMOS L=1.00u W=36.0u       ; M device
M136t 1 0 2 3 PMOS L=0.35u W=36.4u       ; M device
R136u 2 3 63k                            ; R device
M136v 0 3 1 2 NMOS L=0.70u W=43.5u AD=41.37p AS=22.78p PD=164.6u PS=144.4u ; M device
M136w 2 3 1 0 NMOS L=0.10u W=2.7u AD=1.78p AS=5.10p PD=6.2u PS=10.2u ; M device
C136x 0 2 10.0m                          ; C device
M136y 2 0 1 3 NMOS L=0.18u W=56.9u AD=106.02p AS=109.74p PD=192.8u PS=211.7u ; M device
M136z 1 0 3 2 NMOS L=0.18u W=98.4u AD=187.67p AS=177.93p PD=269.6u PS=204.6u ; M device
R137a 3 1 2.9M                           ; R device
M137b 0 2 3 1 NMOS L=1.00u W=15.6u AD=23.65p AS=13.05p PD=60.8u PS=44.3u ; M device
R137c 3 2 5.0M                           ; R device
C137d 2 0 96n                            ; C device
M137e 2 1 3 0 PMOS L=0.35u W=30.0u
+ AD=36.39p AS=50.35p PD=60.7u PS=86.0u ; M device
C137f 0 1 5.3m                           ; C device
M137g 3 2 0 1 PMOS L=0.50u W=95.0u       ; M device
R137h 3 2 35                             ; R device
M137i 2 3 1 0 PMOS L=0.50u W=77.0u       ; M device
C137j 3 0 56n                            ; C device
R137k 3 0 39k                            ; R device
M137l 3 2 0 1 PMOS L=0.70u W=20.8u
+ AD=39.14p AS=19.68p PD=57.0u PS=48.1u ; M device
C137m 0 3 253p                           ; C device
M137n 2 0 1 3 PMOS L=0.50u W=92.0u
+ AD=42.00p AS=154.66p PD=360.8u PS=194.7u ; M device
M137o 1 2 3 0 NMOS L=0.18u W=43.7u       ; M device
C137p 1 3 18n                            ; C device
M137q 3 0 1 2 NMOS L=0.13u W=28.9u AD=14.55p AS=6.46p PD=88.3u PS=95.8u ; M device
M137r 2 3 1 0 NMOS L=0.18u W=85.5u       ; M device
M137s 1 0 3 2 NMOS L=0.35u W=62.4u
+ AD=42.02p AS=8.81p PD=145.4u PS=196.7u ; M device
R137t 3 2 840                            ; R device
M137u 0 3 1 2 PMOS L=0.70u W=91.7u AD=39.19p AS=83.13p PD=305.1u PS=357.2u ; M device
C137v 1 3 8.8m                           ; C device
C137w 2 1 2.9m                           ; C device
R137x 2 0 58k                            ; R device
M137y 0 3 2 1 PMOS L=1.00u W=35.2u AD=62.94p AS=51.44p PD=77.0u PS=82.6u ; M device
M137z 2 1 3 0 NMOS L=1.00u W=69.4u       ; M device
M138a 0 1 3 2 NMOS L=1.00u W=14.1u       ; M device
C138b 0 3 0.1u                           ; C device
M138c 1 3 0 2 PMOS L=0.10u W=52.5u AD=36.94p AS=60.55p PD=178.1u PS=107.6u ; M device
M138d 2 1 3 0 NMOS L=0.35u W=41.1u AD=29.23p AS=42.97p PD=150.5u PS=135.0u ; M device
M138e 0 2 3 1 PMOS L=0.35u W=92.5u       ; M device
C138f 0 1 2.8m                           ; C device
R138g 1 2 7k                             ; R device
M138h 0 1 3 2 NMOS L=0.10u W=11.0u
+ AD=16.94p AS=10.80p PD=29.0u PS=42.9u ; M device
M138i 1 2 3 0 NMOS L=0.50u W=88.8u       ; M device
C138j 3 0 6.4u                           ; C device
M138k 3 2 1 0 PMOS L=0.25u W=68.4u AD=105.95p AS=119.20p PD=207.8u PS=250.2u ; M device
M138l 0 3 1 2 PMOS L=0.25u W=87.8u       ; M device
R138m 2 1 929                            ; R device
R138n 0 1 596                            ; R device
R138o 0 1 74k                            ; R device
R138p 2 3 696                            ; R device
R138q 1 0 903                            ; R device
C138r 3 0 679p                           ; C device
M138s 3 0 1 2 NMOS L=0.13u W=81.1u AD=65.17p AS=20.88p PD=290.6u PS=226.5u ; M device
C138t 3 1 55n                            ; C device
R138u 0 3 2.8M                           ; R device
C138v 3 0 80n                            ; C device
R138w 2 1 98k                            ; R device
M138x 1 3 2 0 PMOS L=0.25u W=54.2u       ; M device
M138y 2 1 0 3 PMOS L=0.18u W=23.1u AD=13.64p AS=25.30p PD=87.3u PS=47.4u ; M device
M138z 3 1 2 0 PMOS L=0.35u W=59.5u
+ AD=89.75p AS=90.20p PD=166.0u PS=141.2u ; M device
R139a 3 2 52k                            ; R device
C139b 3 0 46n                            ; C device
M139c 3 2 0 1 NMOS L=0.25u W=4.1u        ; M device
R139d 1 2 913                            ; R device
R139e 3 2 2.9M                           ; R device
C139f 0 1 38n                            ; C device
C139g 3 2 0.5u                           ; C device
M139h 0 3 1 2 PMOS L=0.18u W=4.5u AD=4.71p AS=1.88p PD=12.3u PS=10.6u ; M device
C139i 1 0 565p                           ; C device
C139j 0 2 85n                            ; C device
R139k 0 1 32k                            ; R device
M139l 2 0 1 3 PMOS L=0.25u W=41.4u       ; M device
R139m 0 3 401                            ; R device
R139n 1 3 4.2M                           ; R device
M139o 2 0 3 1 PMOS L=1.00u W=22.2u       ; M device
R139p 1 2 30k                            ; R device
C139q 3 1 0.1m                           ; C device
M139r 1 2 3 0 PMOS L=0.50u W=44.5u       ; M device
M139s 0 2 3 1 NMOS L=0.13u W=7.1u AD=8.68p AS=9.91p PD=21.2u PS=21.0u ; M device
R139t 0 3 666                            ; R device
C139u 1 3 4.6u                           ; C device
R139v 0 3 451                            ; R device
R139w 1 0 3.2M                           ; R device
M139x 0 1 3 2 NMOS L=0.50u W=71.5u       ; M device
M139y 1 0 2 3 NMOS L=0.35u W=19.0u
+ AD=4.01p AS=12.40p PD=57.5u PS=62.5u ; M device
R139z 1 2 6.2M                           ; R device
C140a 1 3 1.7m                           ; C device
M140b 2 0 1 3 NMOS L=0.10u W=2.4u
+ AD=3.69p AS=3.98p PD=7.5u PS=8.7u ; M device
R140c 1 2 9.4M                           ; R device
C140d 0 2 254p                           ; C device
C140e 0 1 902p                           ; C device
C140f 1 0 88n                            ; C device
M140g 3 2 0 1 PMOS L=0.35u W=55.6u       ; M device
M140h 2 0 1 3 NMOS L=0.13u W=16.0u
+ AD=16.68p AS=19.12p PD=38.8u PS=59.3u ; M device
R140i 2 3 20k                            ; R device
C140j 0 3 7.4u                           ; C device
C140k 0 2 5n                             ; C device
R140l 0 1 7.0M                           ; R device
R140m 2 3 59k                            ; R device
R140n 0 3 76k                            ; R device
R140o 3 2 451                            ; R device
R140p 2 3 15k                            ; R device
C140q 0 2 6.0u                           ; C device
M140r 0 2 1 3 NMOS L=0.50u W=78.2u AD=131.02p AS=27.58p PD=275.3u PS=206.5u ; M device
R140s 0 1 3.1M                           ; R device
C140t 1 2 9.2m                           ; C device
M140u 2 3 0 1 NMOS L=0.18u W=8.1u
+ AD=5.13p AS=5.99p PD=17.8u PS=29.5u ; M device
M140v 1 3 0 2 NMOS L=0.50u W=69.5u AD=35.59p AS=12.77p PD=183.6u PS=143.6u ; M device
R140w 0 2 29k                            ; R device
M140x 3 1 2 0 NMOS L=1.00u W=78.3u AD=58.96p AS=141.01p PD=290.0u PS=247.4u ; M device
C140y 3 1 33n                            ; C device
M140z 2 1 0 3 NMOS L=0.10u W=84.0u       ; M device
M141a 3 2 0 1 NMOS L=0.10u W=96.3u       ; M device
M141b 1 2 0 3 NMOS L=0.50u W=72.8u
+ AD=59.34p AS=67.16p PD=206.8u PS=194.2u ; M device
M141c 2 3 1 0 PMOS L=1.00u W=40.6u       ; M device
M141d 3 1 0 2 NMOS L=0.13u W=76.6u       ; M device
R141e 2 0 5.3M                           ; R device
C141f 1 2 110p                           ; C device
M141g 3 1 2 0 PMOS L=0.13u W=57.3u
+ AD=78.77p AS=70.76p PD=185.4u PS=147.7u ; M device
R141h 2 1 69k                            ; R device
R141i 2 0 8.6M                           ; R device
R141j 2 3 3.0M                           ; R device
M141k 2 1 3 0 PMOS L=0.18u W=18.5u
+ AD=10.72p AS=32.16p PD=51.1u PS=63.8u ; M device
M141l 0 3 2 1 PMOS L=0.13u W=75.8u       ; M device
C141m 3 1 95n                            ; C device
R141n 2 3 4.0M                           ; R device
R141o 1 0 76k                            ; R device
M141p 1 2 3 0 PMOS L=0.50u W=26.4u AD=46.05p AS=51.21p PD=99.6u PS=80.7u ; M device
M141q 3 0 1 2 NMOS L=0.35u W=93.7u
+ AD=29.40p AS=104.12p PD=198.4u PS=328.1u ; M device
C141r 0 3 496p                           ; C device
R141s 2 3 1.1M                           ; R device
R141t 1 3 8.4M                           ; R device
R141u 1 0 9.8M                           ; R device
M141v 3 1 0 2 NMOS L=1.00u W=3.9u        ; M device
R141w 1 3 292                            ; R device
C141x 2 0 419p                           ; C device
C141y 1 2 10n                            ; C device
C141z 1 0 3.0u                           ; C device
M142a 0 2 1 3 PMOS L=0.18u W=44.9u
+ AD=32.83p AS=59.24p PD=138.2u PS=90.0u ; M device
M142b 1 2 3 0 NMOS L=0.13u W=89.0u       ; M device
M142c 0 2 1 3 PMOS L=1.00u W=11.3u       ; M device
M142d 3 1 0 2 PMOS L=0.18u W=4.6u        ; M device
M142e 2 1 3 0 PMOS L=0.18u W=21.1u       ; M device
C142f 2 1 4.7m                           ; C device
M142g 3 1 0 2 NMOS L=0.70u W=3.4u AD=2.57p AS=1.71p PD=10.0u PS=11.8u ; M device
M142h 0 2 1 3 NMOS L=0.18u W=41.7u       ; M device
R142i 2 0 1.7M                           ; R device
R142j 1 2 912                            ; R device
M142k 1 3 2 0 PMOS L=1.00u W=56.0u
+ AD=66.86p AS=79.22p PD=116.7u PS=213.4u ; M device
R142l 0 1 631                            ; R device
R142m 3 2 443                            ; R device
R142n 3 1 678                            ; R device
M142o 0 3 2 1 NMOS L=0.10u W=97.0u
+ AD=163.28p AS=167.66p PD=296.8u PS=364.4u ; M device
R142p 0 3 629                            ; R device
C142q 0 1 0.8u                           ; C device
R142r 1 3 33                             ; R device
R142s 2 3 15k                            ; R device
R142t 3 1 8.0M                           ; R device
R142u 2 3 4.1M                           ; R device
R142v 3 0 185                            ; R device
C142w 1 0 9.3u                           ; C device
R142x 0 2 279                            ; R device
C142y 3 1 14n                            ; C device
R142z 0 3 5.1M                           ; R device
R143a 2 3 63k                            ; R device
C143b 0 3 85n                            ; C device
M143c 2 0 3 1 PMOS L=0.13u W=21.9u       ; M device
C143d 0 2 690p                           ; C device
R143e 3 2 907                            ; R device
R143f 3 2 770                            ; R device
C143g 1 3 93n                            ; C device
R143h 3 1 569                            ; R device
M143i 2 0 1 3 PMOS L=1.00u W=17.7u AD=7.87p AS=25.40p PD=70.9u PS=65.7u ; M device
M143j 3 2 0 1 PMOS L=0.18u W=18.4u       ; M device
M143k 0 1 2 3 PMOS L=0.70u W=51.6u       ; M device
R143l 3 0 53k                            ; R device
M143m 3 0 2 1 NMOS L=0.25u W=13.8u AD=8.59p AS=9.55p PD=39.7u PS=30.8u ; M device
R143n 1 3 259                            ; R device
C143o 2 3 34n                            ; C device
M143p 0 3 1 2 NMOS L=0.25u W=80.6u AD=95.51p AS=98.16p PD=261.0u PS=227.7u ; M device
C143q 0 3 806p                           ; C device
R143r 0 2 5.1M                           ; R device
C143s 2 0 240p                           ; C device
M143t 0 2 1 3 NMOS L=1.00u W=6.2u        ; M device
R143u 2 1 8k                             ; R device
R143v 1 3 999                            ; R device
R143w 3 1 25k                            ; R device
C143x 1 3 4.5m                           ; C device
R143y 1 3 3.3M                           ; R device
C143z 2 1 943p                           ; C device
M144a 1 3 0 2 PMOS L=1.00u W=13.9u       ; M device
C144b 3 1 64n                            ; C device
M144c 0 3 2 1 NMOS L=0.70u W=20.9u       ; M device
R144d 3 0 46k                            ; R device
C144e 3 1 94n                            ; C device
R144f 2 1 18k                            ; R device
R144g 1 3 30k                            ; R device
M144h 2 3 1 0 NMOS L=0.25u W=97.0u AD=111.11p AS=71.04p PD=206.1u PS=204.6u ; M device
M144i 0 3 1 2 PMOS L=0.70u W=14.9u       ; M device
C144j 3 0 1.5u                           ; C device
C144k 0 2 1.0u                           ; C device
R144l 2 0 69k                            ; R device
R144m 1 3 28k                            ; R device
M144n 0 3 1 2 NMOS L=1.00u W=62.5u AD=75.41p AS=21.94p PD=166.5u PS=215.3u ; M device
M144o 2 1 3 0 NMOS L=0.10u W=79.3u AD=72.03p AS=17.99p PD=288.4u PS=252.1u ; M device
M144p 2 0 3 1 NMOS L=0.70u W=90.8u       ; M device
C144q 0 2 61n                            ; C device
R144r 0 1 717                            ; R device
C144s 0 2 3.0m                           ; C device
M144t 0 2 3 1 NMOS L=0.70u W=37.4u       ; M device
C144u 0 3 715p                           ; C device
R144v 2 0 4.0M                           ; R device
C144w 3 0 351p                           ; C device
R144x 2 3 1.1M                           ; R device
R144y 3 2 50k                            ; R device
R144z 1 0 5.5M                           ; R device
M145a 1 2 0 3 PMOS L=0.18u W=39.1u       ; M device
C145b 0 2 12n                            ; C device
C145c 2 3 1.9m                           ; C device
R145d 1 0 36k                            ; R device
R145e 3 1 2.8M                           ; R device
R145f 0 2 4.4M                           ; R device
R145g 3 0 80k                            ; R device
M145h 2 3 0 1 PMOS L=0.10u W=90.4u
+ AD=51.97p AS=120.07p PD=219.2u PS=310.0u ; M device
R145i 1 2 3.5M                           ; R device
M145j 3 1 2 0 NMOS L=0.13u W=2.5u
+ AD=2.66p AS=4.99p PD=6.9u PS=5.2u ; M device
M145k 2 1 3 0 PMOS L=0.13u W=32.4u       ; M device
R145l 0 2 4.5M                           ; R device
R145m 1 2 76k                            ; R device
R145n 3 0 1.2M                           ; R device
C145o 3 2 3.6m                           ; C device
M145p 1 0 2 3 NMOS L=0.70u W=66.9u
+ AD=66.59p AS=18.85p PD=253.1u PS=221.5u ; M device
R145q 3 2 3.2M                           ; R device
C145r 0 2 154p                           ; C device
M145s 0 2 3 1 NMOS L=1.00u W=6.4u        ; M device
R145t 2 0 67k                            ; R device
M145u 0 1 2 3 NMOS L=0.50u W=73.4u AD=34.41p AS=77.28p PD=225.1u PS=247.4u ; M device
M145v 2 0 3 1 PMOS L=0.35u W=5.9u
+ AD=3.76p AS=5.53p PD=15.7u PS=12.1u ; M device
M145w 0 1 2 3 PMOS L=0.10u W=16.2u       ; M device
M145x 3 0 1 2 NMOS L=1.00u W=82.0u
+ AD=140.16p AS=61.39p PD=313.7u PS=254.6u ; M device
M145y 2 1 0 3 NMOS L=0.35u W=21.0u       ; M device
M145z 3 2 1 0 PMOS L=0.25u W=63.5u
+ AD=117.24p AS=81.76p PD=155.7u PS=176.0u ; M device
C146a 0 3 699p                           ; C device
M146b 0 1 3 2 PMOS L=0.18u W=7.1u        ; M device
M146c 1 0 3 2 PMOS L=0.35u W=38.4u       ; M device
M146d 2 0 1 3 PMOS L=0.70u W=52.1u       ; M device
M146e 0 1 3 2 PMOS L=0.70u W=7.2u        ; M device
M146f 1 3 0 2 NMOS L=0.70u W=48.2u       ; M device
R146g 3 2 10k                            ; R device
R146h 0 1 111                            ; R device
M146i 2 1 3 0 PMOS L=0.25u W=37.2u AD=66.05p AS=64.44p PD=108.5u PS=115.1u ; M device
R146j 1 2 183                            ; R device
M146k 1 3 0 2 PMOS L=0.70u W=56.7u       ; M device
C146l 2 0 2.0m                           ; C device
M146m 1 2 0 3 NMOS L=0.13u W=85.5u
+ AD=9.65p AS=111.51p PD=292.8u PS=300.1u ; M device
M146n 3 1 0 2 NMOS L=0.10u W=25.2u       ; M device
C146o 3 0 7.1m                           ; C device
M146p 1 0 3 2 NMOS L=0.13u W=89.5u       ; M device
C146q 1 3 8.9u                           ; C device
R146r 2 0 415                            ; R device
R146s 0 2 7.0M                           ; R device
M146t 1 2 0 3 PMOS L=0.50u W=25.6u
+ AD=16.82p AS=38.95p PD=89.4u PS=55.9u ; M device
R146u 2 1 835                            ; R device
C146v 3 0 23n                            ; C device
C146w 2 1 2.6m                           ; C device
M146x 3 1 2 0 PMOS L=1.00u W=4.7u
+ AD=2.27p AS=2.60p PD=9.8u PS=17.7u ; M device
C146y 3 2 3.7u                           ; C device
C146z 2 3 3.0u                           ; C device
M147a 2 0 3 1 NMOS L=0.25u W=64.4u AD=84.75p AS=64.11p PD=202.3u PS=144.7u ; M device
M147b 1 2 3 0 NMOS L=1.00u W=58.0u AD=83.51p AS=40.30p PD=192.2u PS=158.1u ; M device
R147c 3 2 7.0M                           ; R device
M147d 1 2 3 0 PMOS L=0.13u W=78.2u
+ AD=33.24p AS=141.18p PD=214.8u PS=278.3u ; M device
C147e 1 2 525p                           ; C device
M147f 2 3 1 0 NMOS L=1.00u W=24.2u       ; M device
M147g 2 0 3 1 NMOS L=0.10u W=28.7u       ; M device
C147h 1 2 0.2m                           ; C device
C147i 2 1 12n                            ; C device
M147j 0 1 2 3 NMOS L=1.00u W=41.5u AD=39.00p AS=51.96p PD=92.0u PS=106.9u ; M device
R147k 3 2 236                            ; R device
R147l 0 1 210                            ; R device
M147m 0 2 3 1 PMOS L=0.35u W=75.7u AD=42.59p AS=57.94p PD=292.2u PS=188.9u ; M device
M147n 0 3 1 2 NMOS L=0.10u W=88.3u
+ AD=88.49p AS=152.04p PD=261.7u PS=256.1u ; M device
R147o 3 1 78k                            ; R device
M147p 3 2 0 1 NMOS L=0.70u W=33.4u
+ AD=66.35p AS=47.60p PD=99.1u PS=68.4u ; M device
M147q 2 1 0 3 PMOS L=0.50u W=92.3u
+ AD=30.11p AS=152.56p PD=311.2u PS=203.0u ; M device
C147r 3 1 3.5u                           ; C device
C147s 0 1 63n                            ; C device
M147t 1 3 0 2 PMOS L=0.18u W=60.4u
+ AD=93.19p AS=63.55p PD=123.1u PS=222.7u ; M device
C147u 2 0 98n                            ; C device
M147v 1 2 3 0 PMOS L=0.70u W=48.3u       ; M device
C147w 0 3 532p                           ; C device
C147x 2 1 32n                            ; C device
M147y 1 3 2 0 PMOS L=0.18u W=25.6u
+ AD=21.49p AS=5.99p PD=77.3u PS=87.7u ; M device
C147z 2 3 3.9u                           ; C device
M148a 1 2 0 3 NMOS L=0.35u W=51.4u AD=90.32p AS=92.84p PD=122.6u PS=204.8u ; M device
R148b 0 1 67                             ; R device
C148c 3 1 606p                           ; C device
C148d 1 2 86n                            ; C device
M148e 0 2 3 1 PMOS L=0.13u W=89.2u       ; M device
R148f 2 0 1.1M                           ; R device
C148g 1 2 7.8u                           ; C device
M148h 0 2 1 3 NMOS L=0.50u W=38.3u       ; M device
C148i 1 3 3.4u                           ; C device
M148j 3 2 0 1 PMOS L=0.18u W=20.0u
+ AD=27.51p AS=8.26p PD=48.9u PS=48.4u ; M device
R148k 3 0 83k                            ; R device
R148l 3 1 53k                            ; R device
C148m 1 3 7.5m                           ; C device
M148n 3 0 2 1 NMOS L=0.18u W=80.2u       ; M device
M148o 3 1 0 2 NMOS L=0.50u W=30.9u       ; M device
C148p 3 2 80n                            ; C device
M148q 1 0 3 2 NMOS L=0.10u W=33.1u
+ AD=9.96p AS=25.41p PD=119.9u PS=103.0u ; M device
R148r 0 3 143                            ; R device
R148s 2 0 86k                            ; R device
C148t 3 0 99n                            ; C device
C148u 0 2 7.3m                           ; C device
R148v 1 3 56k                            ; R device
M148w 0 2 3 1 NMOS L=1.00u W=48.1u       ; M device
C148x 1 3 69n                            ; C device
R148y 0 1 8.4M                           ; R device
C148z 2 0 581p                           ; C device
R149a 0 1 69k                            ; R device
R149b 1 3 224                            ; R device
M149c 0 2 3 1 PMOS L=0.13u W=68.7u AD=101.97p AS=62.74p PD=139.3u PS=214.4u ; M device
C149d 1 0 4.5u                           ; C device
M149e 0 3 2 1 NMOS L=0.70u W=44.5u AD=53.50p AS=79.11p PD=163.4u PS=95.0u ; M device
C149f 3 1 3.6m                           ; C device
C149g 1 2 466p                           ; C device
R149h 1 0 97k                            ; R device
R149i 0 3 123                            ; R device
C149j 2 1 35n                            ; C device
R149k 3 1 88k                            ; R device
M149l 3 1 0 2 PMOS L=0.10u W=22.6u AD=10.58p AS=30.09p PD=74.4u PS=59.9u ; M device
M149m 1 3 0 2 PMOS L=1.00u W=51.9u AD=26.33p AS=25.09p PD=132.9u PS=169.4u ; M device
C149n 2 0 0.6m                           ; C device
C149o 3 2 492p                           ; C device
C149p 1 2 4.2m                           ; C device
C149q 2 3 5.4m                           ; C device
C149r 3 0 7.7m                           ; C device
C149s 0 3 30n                            ; C device
M149t 2 1 3 0 PMOS L=0.10u W=84.9u       ; M device
M149u 0 1 2 3 PMOS L=0.10u W=52.1u
+ AD=93.36p AS=70.10p PD=155.0u PS=199.0u ; M device
C149v 2 3 47n                            ; C device
C149w 1 3 3.6u                           ; C device
M149x 3 2 0 1 NMOS L=0.70u W=57.4u       ; M device
M149y 1 3 0 2 NMOS L=1.00u W=88.9u       ; M device
M149z 2 0 3 1 NMOS L=0.70u W=28.4u       ; M device
M150a 0 1 3 2 NMOS L=0.50u W=86.7u
+ AD=71.18p AS=97.05p PD=251.9u PS=294.1u ; M device
M150b 2 1 0 3 NMOS L=1.00u W=74.8u
+ AD=10.64p AS=92.08p PD=155.9u PS=273.5u ; M device
M150c 0 2 3 1 PMOS L=0.18u W=87.6u       ; M device
M150d 1 0 3 2 PMOS L=1.00u W=7.0u
+ AD=1.42p AS=8.31p PD=17.9u PS=19.7u ; M device
R150e 1 0 6.4M                           ; R device
M150f 2 3 0 1 PMOS L=0.25u W=64.8u
+ AD=97.07p AS=111.63p PD=235.4u PS=136.0u ; M device
M150g 0 2 1 3 NMOS L=0.18u W=76.8u
+ AD=153.09p AS=42.41p PD=289.7u PS=275.7u ; M device
R150h 0 3 609                            ; R device
C150i 0 3 33p                            ; C device
R150j 2 1 4.7M                           ; R device
C150k 0 1 5.7m                           ; C device
M150l 2 3 1 0 PMOS L=0.70u W=86.5u AD=165.36p AS=66.09p PD=247.1u PS=211.1u ; M device
M150m 0 3 2 1 PMOS L=0.13u W=92.2u       ; M device
C150n 2 0 3.2m                           ; C device
M150o 1 0 3 2 NMOS L=0.50u W=53.7u AD=55.55p AS=80.62p PD=164.9u PS=171.3u ; M device
C150p 3 1 87n                            ; C device
R150q 0 3 71k                            ; R device
C150r 1 3 6.6u                           ; C device
R150s 1 3 97k                            ; R device
R150t 3 2 36k                            ; R device
C150u 2 1 5.9m                           ; C device
M150v 0 2 3 1 NMOS L=0.10u W=40.6u       ; M device
C150w 3 1 8.6u                           ; C device
C150x 2 0 36n                            ; C device
C150y 2 1 6.0u                           ; C device
M150z 1 3 0 2 PMOS L=0.10u W=51.8u       ; M device
C151a 0 2 8.6u                           ; C device
R151b 0 2 95                             ; R device
C151c 3 0 39n                            ; C device
M151d 2 3 1 0 NMOS L=0.13u W=13.6u       ; M device
M151e 2 0 3 1 NMOS L=0.35u W=35.6u       ; M device
C151f 1 2 0.3u                           ; C device
C151g 2 1 82n                            ; C device
C151h 2 3 3.7u                           ; C device
M151i 3 2 1 0 PMOS L=0.25u W=31.8u       ; M device
R151j 1 0 399                            ; R device
C151k 2 1 127p                           ; C device
C151l 3 1 4.6u                           ; C device
R151m 3 0 61k                            ; R device
R151n 3 0 868                            ; R device
C151o 0 1 1.4u                           ; C device
C151p 2 0 7.1u                           ; C device
C151q 3 1 5.8u                           ; C device
C151r 3 0 67n                            ; C device
R151s 1 3 63k                            ; R device
C151t 1 0 4n                             ; C device
R151u 2 3 420                            ; R device
M151v 1 0 3 2 NMOS L=0.18u W=97.3u       ; M device
R151w 1 2 696                            ; R device
R151x 0 3 672                            ; R device
M151y 1 0 2 3 NMOS L=0.18u W=74.0u AD=80.05p AS=80.53p PD=187.4u PS=254.6u ; M device
C151z 0 1 433p                           ; C device
C152a 2 1 5.9u                           ; C device
R152b 3 1 6k                             ; R device
M152c 3 1 0 2 NMOS L=1.00u W=80.0u       ; M device
C152d 1 3 641p                           ; C device
C152e 0 2 1.9u                           ; C device
C152f 0 3 47n                            ; C device
C152g 0 3 541p                           ; C device
M152h 1 2 0 3 PMOS L=1.00u W=16.9u       ; M device
R152i 0 2 441                            ; R device
C152j 0 3 4.0m                           ; C device
M152k 2 3 0 1 PMOS L=1.00u W=20.0u AD=29.80p AS=38.00p PD=64.9u PS=63.3u ; M device
C152l 2 3 5n                             ; C device
R152m 2 0 70k                            ; R device
M152n 3 2 0 1 PMOS L=0.70u W=20.4u AD=10.21p AS=37.31p PD=78.9u PS=62.2u ; M device
R152o 0 1 3.9M                           ; R device
C152p 3 2 801p                           ; C device
C152q 1 2 98n                            ; C device
C152r 0 1 6.3u                           ; C device
M152s 1 3 0 2 PMOS L=0.10u W=66.4u AD=95.27p AS=57.20p PD=225.8u PS=162.6u ; M device
M152t 3 1 0 2 PMOS L=1.00u W=81.3u AD=48.97p AS=131.75p PD=198.5u PS=248.8u ; M device
C152u 3 0 4.9u                           ; C device
M152v 0 2 3 1 PMOS L=0.50u W=3.6u AD=2.34p AS=1.76p PD=10.0u PS=13.4u ; M device
C152w 1 0 3.5u                           ; C device
M152x 3 0 1 2 NMOS L=0.70u W=64.8u       ; M device
R152y 2 1 747                            ; R device
R152z 2 1 9.9M                           ; R device
C153a 3 1 3.8u                           ; C device
C153b 3 2 18n                            ; C device
C153c 1 0 95n                            ; C device
C153d 2 1 10p                            ; C device
M153e 0 3 1 2 NMOS L=0.13u W=98.9u       ; M device
R153f 2 0 347                            ; R device
C153g 0 1 169p                           ; C device
R153h 0 3 71k                            ; R device
R153i 2 1 8.4M                           ; R device
C153j 0 2 1.0m                           ; C device
C153k 3 2 415p                           ; C device
C153l 3 0 47n                            ; C device
R153m 0 3 9.0M                           ; R device
M153n 1 2 0 3 NMOS L=0.18u W=92.3u       ; M device
C153o 1 3 8.5m                           ; C device
M153p 1 0 2 3 PMOS L=0.50u W=93.3u AD=33.24p AS=71.63p PD=211.2u PS=186.8u ; M device
R153q 2 3 29k                            ; R device
M153r 2 3 0 1 NMOS L=0.18u W=31.5u AD=35.63p AS=10.76p PD=90.4u PS=114.5u ; M device
C153s 2 0 6.9m                           ; C device
C153t 3 0 9.0m                           ; C device
R153u 3 1 69k                            ; R device
R153v 2 3 4.1M                           ; R device
M153w 1 0 3 2 PMOS L=1.00u W=26.2u AD=7.56p AS=13.09p PD=103.9u PS=53.8u ; M device
R153x 0 2 8.5M                           ; R device
M153y 0 2 3 1 PMOS L=0.18u W=58.0u       ; M device
C153z 3 0 3n                             ; C device
M154a 2 0 1 3 NMOS L=1.00u W=13.2u
+ AD=18.08p AS=4.24p PD=33.4u PS=40.7u ; M device
R154b 0 2 969                            ; R device
R154c 2 0 0.3M                           ; R device
R154d 0 2 6.7M                           ; R device
M154e 1 2 0 3 PMOS L=0.13u W=70.6u       ; M device
M154f 0 2 3 1 NMOS L=0.35u W=63.7u       ; M device
C154g 1 3 31n                            ; C device
M154h 3 2 0 1 NMOS L=0.18u W=45.8u       ; M device
R154i 2 0 774                            ; R device
R154j 2 0 7.5M                           ; R device
M154k 3 0 2 1 PMOS L=0.18u W=48.9u       ; M device
R154l 1 3 711                            ; R device
C154m 0 2 8.5m                           ; C device
C154n 1 0 92n                            ; C device
M154o 2 1 3 0 NMOS L=0.70u W=73.8u
+ AD=131.79p AS=118.82p PD=173.1u PS=201.5u ; M device
M154p 3 2 0 1 NMOS L=1.00u W=40.0u
+ AD=47.41p AS=53.02p PD=133.5u PS=146.7u ; M device
C154q 3 0 9.3u                           ; C device
C154r 1 0 567p                           ; C device
C154s 3 2 0.1u                           ; C device
M154t 0 2 3 1 NMOS L=0.18u W=99.5u AD=35.79p AS=74.09p PD=259.3u PS=378.8u ; M device
R154u 3 1 77k                            ; R device
C154v 2 0 722p                           ; C device
R154w 3 0 394                            ; R device
M154x 0 2 3 1 NMOS L=0.13u W=55.4u       ; M device
C154y 3 2 3.2m                           ; C device
R154z 0 1 44k                            ; R device
C155a 3 2 87n                            ; C device
M155b 0 2 1 3 NMOS L=0.10u W=43.8u
+ AD=17.57p AS=47.90p PD=164.3u PS=112.6u ; M device
C155c 3 2 853p                           ; C device
R155d 3 0 9.4M                           ; R device
M155e 1 0 2 3 PMOS L=0.35u W=8.1u        ; M device
R155f 2 1 592                            ; R device
M155g 1 0 2 3 NMOS L=0.10u W=83.4u
+ AD=99.87p AS=77.92p PD=228.4u PS=304.5u ; M device
C155h 3 2 94n                            ; C device
C155i 0 1 0.6u                           ; C device
M155j 2 0 3 1 NMOS L=1.00u W=1.1u        ; M device
C155k 2 1 6.6u                           ; C device
M155l 0 2 1 3 NMOS L=0.70u W=56.7u AD=19.37p AS=14.92p PD=203.7u PS=126.0u ; M device
M155m 1 0 2 3 PMOS L=0.50u W=3.5u AD=2.32p AS=1.88p PD=10.8u PS=14.0u ; M device
M155n 2 1 3 0 PMOS L=0.25u W=85.2u AD=139.36p AS=70.45p PD=184.0u PS=245.5u ; M device
M155o 0 3 1 2 NMOS L=0.10u W=69.4u       ; M device
M155p 2 3 1 0 PMOS L=0.10u W=88.3u
+ AD=93.26p AS=13.14p PD=274.4u PS=192.3u ; M device
M155q 1 0 2 3 NMOS L=0.18u W=12.6u       ; M device
M155r 0 2 1 3 NMOS L=0.10u W=15.5u       ; M device
C155s 1 2 325p                           ; C device
R155t 2 3 21k                            ; R device
R155u 3 1 854                            ; R device
C155v 1 2 710p                           ; C device
M155w 3 2 0 1 PMOS L=0.18u W=25.9u       ; M device
R155x 3 0 95k                            ; R device
R155y 1 2 116                            ; R device
C155z 0 1 8.9m                           ; C device
C156a 1 0 1.7m                           ; C device
M156b 1 2 3 0 NMOS L=1.00u W=36.1u AD=23.92p AS=70.04p PD=129.6u PS=79.9u ; M device
M156c 3 2 1 0 NMOS L=0.18u W=46.8u AD=77.74p AS=90.23p PD=145.2u PS=105.3u ; M device
R156d 0 2 62k                            ; R device
M156e 0 2 3 1 PMOS L=0.18u W=61.4u       ; M device
R156f 2 3 79k                            ; R device
C156g 2 3 6.3u                           ; C device
R156h 0 1 22k                            ; R device
M156i 0 2 3 1 PMOS L=0.50u W=81.6u AD=52.46p AS=148.15p PD=201.7u PS=199.9u ; M device
M156j 2 0 3 1 PMOS L=0.10u W=76.4u       ; M device
M156k 0 3 1 2 NMOS L=0.50u W=81.2u       ; M device
R156l 0 2 39k                            ; R device
R156m 2 3 4.4M                           ; R device
M156n 1 0 2 3 NMOS L=0.18u W=76.9u       ; M device
C156o 1 3 877p                           ; C device
R156p 2 3 37k                            ; R device
M156q 2 3 0 1 PMOS L=1.00u W=12.4u       ; M device
C156r 3 0 75n                            ; C device
R156s 2 3 99                             ; R device
C156t 2 1 362p                           ; C device
M156u 2 3 0 1 NMOS L=0.18u W=36.3u       ; M device
R156v 0 2 138                            ; R device
M156w 2 3 0 1 NMOS L=0.35u W=18.4u AD=8.62p AS=28.92p PD=49.3u PS=51.5u ; M device
M156x 0 1 3 2 PMOS L=0.18u W=43.9u
+ AD=77.78p AS=58.23p PD=113.2u PS=104.8u ; M device
C156y 2 3 3.9u                           ; C device
M156z 3 2 0 1 PMOS L=0.70u W=89.2u AD=149.64p AS=170.67p PD=353.7u PS=348.2u ; M device
M157a 3 1 2 0 PMOS L=0.25u W=16.3u AD=30.61p AS=28.54p PD=49.5u PS=50.7u ; M device
C157b 0 2 2.0u                           ; C device
C157c 0 1 6.1u                           ; C device
C157d 1 2 9.2u                           ; C device
R157e 1 2 732                            ; R device
R157f 2 1 51k                            ; R device
R157g 0 1 67                             ; R device
R157h 1 2 388                            ; R device
C157i 0 2 4.2m                           ; C device
C157j 3 0 0.1m                           ; C device
M157k 2 0 1 3 PMOS L=0.70u W=70.4u AD=88.52p AS=71.39p PD=257.9u PS=149.6u ; M device
R157l 0 3 9.0M                           ; R device
M157m 0 1 2 3 PMOS L=0.70u W=74.3u       ; M device
C157n 2 0 0.3m                           ; C device
R157o 2 0 729                            ; R device
C157p 1 3 1.2m                           ; C device
R157q 3 2 81k                            ; R device
M157r 0 3 1 2 NMOS L=1.00u W=40.9u
+ AD=37.59p AS=13.35p PD=163.4u PS=107.7u ; M device
C157s 1 3 9.3u                           ; C device
C157t 1 2 39n                            ; C device
C157u 2 3 6.1u                           ; C device
R157v 1 0 680                            ; R device
R157w 1 0 5k                             ; R device
M157x 0 2 1 3 PMOS L=0.35u W=82.0u       ; M device
C157y 0 1 6.7u                           ; C device
C157z 3 0 6.4u                           ; C device
M158a 3 1 0 2 PMOS L=1.00u W=60.0u       ; M device
C158b 3 1 7.4u                           ; C device
R158c 0 1 7.1M                           ; R device
C158d 0 3 7n                             ; C device
R158e 2 1 91k                            ; R device
C158f 0 2 566p                           ; C device
C158g 3 1 923p                           ; C device
C158h 3 1 69n                            ; C device
C158i 0 2 33n                            ; C device
R158j 1 3 60k                            ; R device
R158k 1 2 9.0M                           ; R device
R158l 3 1 1.9M                           ; R device
M158m 1 0 3 2 NMOS L=1.00u W=42.3u       ; M device
R158n 3 0 69                             ; R device
M158o 3 2 1 0 PMOS L=0.10u W=30.2u       ; M device
C158p 2 0 3.5m                           ; C device
R158q 1 3 772                            ; R device
C158r 0 1 471p                           ; C device
R158s 1 0 2.9M                           ; R device
M158t 1 2 0 3 NMOS L=0.50u W=91.5u AD=31.25p AS=104.59p PD=297.2u PS=331.9u ; M device
R158u 3 1 3.8M                           ; R device
C158v 1 0 14n                            ; C device
M158w 1 0 2 3 PMOS L=0.25u W=16.8u AD=6.13p AS=16.16p PD=50.6u PS=61.8u ; M device
C158x 1 3 75n                            ; C device
M158y 0 3 2 1 PMOS L=0.35u W=76.1u
+ AD=31.57p AS=99.08p PD=184.7u PS=239.4u ; M device
M158z 1 0 2 3 PMOS L=0.50u W=26.6u AD=47.96p AS=40.84p PD=98.7u PS=103.2u ; M device
R159a 2 0 11k                            ; R device
M159b 0 3 2 1 NMOS L=0.35u W=22.9u       ; M device
R159c 3 1 0.2M                           ; R device
R159d 2 1 879                            ; R device
M159e 1 0 3 2 PMOS L=0.13u W=52.8u
+ AD=21.34p AS=9.56p PD=135.0u PS=168.8u ; M device
C159f 2 1 9.5u                           ; C device
R159g 0 3 75k                            ; R device
C159h 1 3 547p                           ; C device
R159i 3 1 808                            ; R device
R159j 2 3 2.8M                           ; R device
M159k 3 2 0 1 PMOS L=0.18u W=33.1u       ; M device
R159l 3 0 6.2M                           ; R device
C159m 2 1 7.7m                           ; C device
C159n 0 3 670p                           ; C device
M159o 1 2 3 0 PMOS L=0.10u W=98.2u AD=99.16p AS=79.93p PD=323.5u PS=302.4u ; M device
M159p 3 0 1 2 NMOS L=0.35u W=73.2u AD=97.04p AS=134.09p PD=169.5u PS=157.8u ; M device
M159q 0 2 1 3 PMOS L=0.25u W=89.7u AD=26.21p AS=85.67p PD=330.3u PS=297.1u ; M device
C159r 3 2 0.5m                           ; C device
R159s 0 2 3.7M                           ; R device
R159t 1 3 8.4M                           ; R device
M159u 1 3 0 2 PMOS L=1.00u W=71.1u AD=95.88p AS=126.23p PD=154.6u PS=191.9u ; M device
C159v 3 0 8.7m                           ; C device
R159w 0 3 740                            ; R device
M159x 2 0 3 1 PMOS L=0.70u W=69.5u
+ AD=122.34p AS=14.34p PD=248.8u PS=213.2u ; M device
M159y 0 1 2 3 NMOS L=0.25u W=99.3u AD=64.88p AS=122.20p PD=255.9u PS=230.6u ; M device
C159z 0 2 4.8u                           ; C device
M160a 2 3 1 0 PMOS L=0.35u W=80.7u AD=12.60p AS=149.48p PD=183.6u PS=262.6u ; M device
M160b 3 2 0 1 PMOS L=0.18u W=69.9u AD=133.95p AS=112.07p PD=209.3u PS=199.7u ; M device
R160c 3 1 730                            ; R device
C160d 1 0 5.2m                           ; C device
M160e 0 3 2 1 PMOS L=0.18u W=41.5u       ; M device
C160f 0 1 726p                           ; C device
C160g 3 0 188p                           ; C device
R160h 1 3 57k                            ; R device
R160i 2 0 65k                            ; R device
R160j 1 3 49k                            ; R device
M160k 3 1 2 0 PMOS L=1.00u W=2.7u        ; M device
C160l 0 3 665p                           ; C device
R160m 1 0 48                             ; R device
R160n 1 0 0.8M                           ; R device
C160o 1 3 6.9u                           ; C device
R160p 3 0 782                            ; R device
M160q 3 0 1 2 NMOS L=0.70u W=84.1u
+ AD=57.21p AS=26.91p PD=211.1u PS=186.6u ; M device
M160r 2 0 3 1 NMOS L=1.00u W=95.9u       ; M device
R160s 2 1 110                            ; R device
C160t 1 0 29p                            ; C device
R160u 3 0 4.5M                           ; R device
R160v 2 3 4.1M                           ; R device
R160w 1 0 63k                            ; R device
R160x 3 1 77k                            ; R device
R160y 3 0 85k                            ; R device
M160z 2 3 0 1 NMOS L=0.13u W=71.2u
+ AD=7.94p AS=30.84p PD=213.0u PS=252.7u ; M device
C161a 0 2 7.2m                           ; C device
M161b 2 1 0 3 PMOS L=0.18u W=41.9u       ; M device
C161c 0 3 0.2m                           ; C device
R161d 2 0 7k                             ; R device
M161e 0 1 2 3 NMOS L=1.00u W=57.7u       ; M device
R161f 2 1 3.6M                           ; R device
C161g 2 3 6.4u                           ; C device
R161h 0 2 0.9M                           ; R device
R161i 0 1 646                            ; R device
R161j 2 3 481                            ; R device
M161k 2 0 1 3 PMOS L=0.70u W=68.0u       ; M device
M161l 3 1 2 0 NMOS L=0.50u W=29.5u AD=7.29p AS=51.25p PD=99.3u PS=100.7u ; M device
R161m 1 0 9.4M                           ; R device
M161n 0 3 1 2 PMOS L=0.50u W=49.8u AD=42.92p AS=89.90p PD=117.3u PS=193.7u ; M device
R161o 2 1 336                            ; R device
C161p 3 2 3.7u                           ; C device
M161q 1 3 0 2 NMOS L=0.70u W=6.2u
+ AD=12.08p AS=2.71p PD=18.8u PS=20.6u ; M device
M161r 0 1 3 2 PMOS L=0.13u W=33.8u       ; M device
R161s 1 0 1.0M                           ; R device
M161t 2 1 3 0 PMOS L=0.10u W=71.7u       ; M device
M161u 3 1 0 2 PMOS L=0.50u W=63.8u
+ AD=48.73p AS=85.47p PD=213.7u PS=154.3u ; M device
M161v 2 0 1 3 NMOS L=0.13u W=38.3u
+ AD=58.72p AS=47.22p PD=121.4u PS=130.4u ; M device
M161w 1 0 3 2 NMOS L=0.35u W=60.2u       ; M device
R161x 2 3 7.5M                           ; R device
C161y 3 1 495p                           ; C device
C161z 0 1 3.8m                           ; C device
R162a 2 0 855                            ; R device
C162b 1 0 5.3m                           ; C device
C162c 1 3 194p                           ; C device
M162d 3 0 1 2 PMOS L=0.50u W=39.8u       ; M device
C162e 0 1 95n                            ; C device
M162f 2 1 3 0 NMOS L=0.18u W=41.4u AD=67.18p AS=58.11p PD=86.2u PS=95.6u ; M device
C162g 3 2 712p                           ; C device
C162h 3 0 69n                            ; C device
M162i 2 1 0 3 PMOS L=0.13u W=94.4u
+ AD=11.85p AS=90.16p PD=258.7u PS=319.9u ; M device
M162j 3 0 2 1 PMOS L=0.18u W=71.7u AD=103.47p AS=73.15p PD=190.7u PS=226.6u ; M device
R162k 1 2 20k                            ; R device
M162l 2 0 1 3 NMOS L=0.25u W=14.7u
+ AD=11.48p AS=12.01p PD=37.9u PS=55.0u ; M device
M162m 0 1 3 2 NMOS L=0.18u W=93.8u
+ AD=25.52p AS=93.23p PD=264.0u PS=213.0u ; M device
C162n 2 0 55n                            ; C device
R162o 1 2 962                            ; R device
R162p 2 1 723                            ; R device
C162q 3 0 41n                            ; C device
R162r 3 1 6.8M                           ; R device
R162s 3 2 463                            ; R device
C162t 3 2 5.3m                           ; C device
R162u 1 2 7.2M                           ; R device
R162v 1 3 562                            ; R device
M162w 2 1 0 3 NMOS L=0.70u W=88.4u
+ AD=82.30p AS=47.70p PD=271.3u PS=233.8u ; M device
M162x 1 0 2 3 PMOS L=0.25u W=79.4u       ; M device
C162y 0 2 119p                           ; C device
C162z 3 1 7.3u                           ; C device
C163a 2 1 55n                            ; C device
C163b 2 3 0.2u                           ; C device
R163c 0 3 1.6M                           ; R device
R163d 3 1 9.1M                           ; R device
C163e 2 3 47n                            ; C device
R163f 1 2 2.5M                           ; R device
R163g 2 1 4.5M                           ; R device
C163h 3 1 56p                            ; C device
R163i 3 2 374                            ; R device
R163j 3 0 22k                            ; R device
R163k 1 3 647                            ; R device
M163l 0 1 3 2 PMOS L=1.00u W=44.5u       ; M device
R163m 0 1 69k                            ; R device
M163n 0 3 1 2 NMOS L=0.18u W=71.4u AD=39.38p AS=63.45p PD=255.1u PS=276.3u ; M device
C163o 2 1 7.2m                           ; C device
M163p 2 0 3 1 NMOS L=0.13u W=5.8u        ; M device
R163q 3 2 8.1M                           ; R device
C163r 2 1 2.8u                           ; C device
R163s 1 0 91k                            ; R device
M163t 3 0 2 1 PMOS L=0.25u W=25.2u
+ AD=5.27p AS=21.14p PD=54.4u PS=80.1u ; M device
R163u 3 1 21k                            ; R device
C163v 0 1 9.1m                           ; C device
R163w 3 2 33k                            ; R device
R163x 1 2 1.2M                           ; R device
C163y 3 2 52n                            ; C device
R163z 3 1 95k                            ; R device
M164a 1 2 0 3 PMOS L=0.50u W=37.2u       ; M device
C164b 0 3 2.5u                           ; C device
C164c 1 2 620p                           ; C device
M164d 1 0 3 2 NMOS L=0.50u W=30.5u       ; M device
M164e 3 1 2 0 NMOS L=0.50u W=12.3u       ; M device
C164f 0 2 446p                           ; C device
M164g 3 1 2 0 NMOS L=0.10u W=6.3u
+ AD=10.06p AS=7.14p PD=22.3u PS=20.6u ; M device
R164h 3 1 77k                            ; R device
M164i 1 0 3 2 NMOS L=1.00u W=44.4u AD=84.34p AS=26.92p PD=156.0u PS=160.0u ; M device
M164j 2 0 1 3 NMOS L=1.00u W=32.9u
+ AD=27.23p AS=9.48p PD=97.4u PS=100.5u ; M device
R164k 0 1 64k                            ; R device
M164l 0 3 1 2 NMOS L=0.50u W=69.1u       ; M device
M164m 1 0 2 3 NMOS L=1.00u W=70.6u       ; M device
M164n 1 0 3 2 PMOS L=1.00u W=44.4u       ; M device
M164o 0 2 1 3 NMOS L=0.25u W=19.8u AD=11.71p AS=29.24p PD=59.0u PS=77.0u ; M device
C164p 2 0 42n                            ; C device
R164q 2 1 80k                            ; R device
R164r 2 3 66k                            ; R device
M164s 2 0 1 3 PMOS L=0.10u W=49.6u       ; M device
R164t 3 1 93k                            ; R device
C164u 2 0 41n                            ; C device
R164v 3 1 2.8M                           ; R device
C164w 2 0 709p                           ; C device
C164x 2 3 16p                            ; C device
R164y 2 3 9.1M                           ; R device
R164z 0 1 315                            ; R device
C165a 2 1 7.3u                           ; C device
R165b 1 0 2.1M                           ; R device
C165c 2 0 9.7m                           ; C device
R165d 2 1 29k                            ; R device
M165e 2 0 1 3 PMOS L=1.00u W=85.4u
+ AD=78.39p AS=169.53p PD=291.4u PS=230.8u ; M device
M165f 0 1 3 2 PMOS L=1.00u W=97.6u       ; M device
C165g 1 2 902p                           ; C device
R165h 2 0 7.0M                           ; R device
R165i 0 2 172                            ; R device
M165j 0 2 1 3 NMOS L=0.35u W=68.8u       ; M device
M165k 0 3 1 2 PMOS L=0.10u W=44.0u       ; M device
M165l 3 0 2 1 PMOS L=0.70u W=75.0u AD=25.45p AS=45.87p PD=208.6u PS=281.4u ; M device
C165m 2 1 0.5m                           ; C device
M165n 1 3 0 2 PMOS L=0.10u W=62.4u       ; M device
C165o 1 2 9.1u                           ; C device
C165p 0 2 3.4u                           ; C device
C165q 0 2 7.7u                           ; C device
C165r 3 0 91n                            ; C device
C165s 2 1 961p                           ; C device
C165t 1 3 60n                            ; C device
C165u 3 0 66n                            ; C device
R165v 1 2 37                             ; R device
M165w 2 3 1 0 PMOS L=0.35u W=83.5u       ; M device
R165x 0 3 82                             ; R device
C165y 1 0 35n                            ; C device
R165z 3 0 501                            ; R device
R166a 3 0 197                            ; R device
C166b 2 3 41n                            ; C device
R166c 2 3 84k                            ; R device
M166d 1 3 2 0 NMOS L=1.00u W=59.5u AD=12.93p AS=83.42p PD=226.1u PS=158.2u ; M device
M166e 1 2 0 3 PMOS L=1.00u W=54.3u       ; M device
C166f 1 3 40n                            ; C device
R166g 2 3 699                            ; R device
R166h 0 1 46k                            ; R device
C166i 2 0 75n                            ; C device
M166j 0 2 1 3 PMOS L=0.10u W=18.5u AD=16.68p AS=17.02p PD=57.0u PS=45.1u ; M device
C166k 1 3 30n                            ; C device
C166l 3 1 6.1m                           ; C device
M166m 3 1 2 0 NMOS L=0.25u W=59.7u
+ AD=106.63p AS=30.49p PD=211.1u PS=134.6u ; M device
M166n 1 2 3 0 NMOS L=0.50u W=60.0u       ; M device
M166o 1 3 2 0 PMOS L=0.13u W=21.6u
+ AD=6.42p AS=17.12p PD=82.5u PS=45.1u ; M device
C166p 3 1 8n                             ; C device
C166q 3 2 5.2m                           ; C device
C166r 3 2 444p                           ; C device
M166s 3 1 2 0 PMOS L=0.50u W=82.9u       ; M device
R166t 0 3 3.4M                           ; R device
R166u 3 0 7.1M                           ; R device
R166v 3 2 805                            ; R device
C166w 1 0 45n                            ; C device
M166x 1 3 2 0 NMOS L=0.25u W=69.8u
+ AD=37.04p AS=96.79p PD=278.3u PS=279.0u ; M device
M166y 3 2 1 0 NMOS L=1.00u W=60.8u AD=45.31p AS=79.35p PD=128.1u PS=129.1u ; M device
R166z 3 2 4.4M                           ; R device
M167a 2 3 1 0 PMOS L=0.35u W=94.0u AD=176.44p AS=66.92p PD=251.1u PS=233.9u ; M device
M167b 2 0 3 1 PMOS L=0.50u W=34.5u       ; M device
R167c 0 1 3.5M                           ; R device
C167d 3 1 805p                           ; C device
C167e 1 3 3.9u                           ; C device
M167f 0 1 3 2 NMOS L=0.10u W=83.9u AD=10.39p AS=109.81p PD=257.8u PS=198.0u ; M device
C167g 0 1 31n                            ; C device
C167h 3 1 719p                           ; C device
R167i 3 2 4.8M                           ; R device
M167j 0 1 2 3 PMOS L=0.18u W=71.0u       ; M device
C167k 0 1 2.5m                           ; C device
R167l 3 2 65k                            ; R device
R167m 2 0 4.0M                           ; R device
C167n 3 1 8.8u                           ; C device
C167o 1 3 1.8m                           ; C device
C167p 3 2 6.8m                           ; C device
M167q 1 2 0 3 PMOS L=0.13u W=88.1u       ; M device
M167r 1 3 0 2 NMOS L=0.10u W=49.1u AD=44.02p AS=30.08p PD=178.4u PS=107.0u ; M device
M167s 1 2 0 3 NMOS L=0.18u W=40.2u
+ AD=31.21p AS=62.55p PD=153.2u PS=102.2u ; M device
C167t 2 1 2.3u                           ; C device
R167u 3 2 976                            ; R device
M167v 0 2 3 1 NMOS L=0.25u W=7.2u AD=3.46p AS=1.99p PD=27.6u PS=21.6u ; M device
M167w 1 2 0 3 PMOS L=0.13u W=87.2u       ; M device
C167x 1 3 57n                            ; C device
C167y 3 2 355p                           ; C device
C167z 3 1 86n                            ; C device
C168a 3 1 220p                           ; C device
M168b 0 2 3 1 PMOS L=0.50u W=99.1u       ; M device
M168c 0 1 2 3 NMOS L=0.25u W=47.9u       ; M device
R168d 0 2 6.7M                           ; R device
M168e 0 1 3 2 NMOS L=0.10u W=48.0u
+ AD=82.22p AS=6.31p PD=142.7u PS=112.1u ; M device
M168f 1 3 2 0 NMOS L=0.13u W=77.3u AD=12.08p AS=55.72p PD=272.8u PS=297.0u ; M device
C168g 2 1 3.9u                           ; C device
R168h 0 2 9.3M                           ; R device
M168i 3 2 0 1 NMOS L=0.50u W=60.8u       ; M device
R168j 0 1 47k                            ; R device
M168k 0 2 3 1 NMOS L=0.25u W=88.5u
+ AD=55.73p AS=143.17p PD=326.8u PS=346.9u ; M device
C168l 3 0 0.8u                           ; C device
R168m 1 0 0.6M                           ; R device
C168n 0 1 764p                           ; C device
R168o 3 2 11k                            ; R device
M168p 1 0 3 2 PMOS L=0.10u W=30.5u AD=20.51p AS=19.52p PD=101.6u PS=81.5u ; M device
M168q 2 1 0 3 NMOS L=1.00u W=51.6u
+ AD=24.30p AS=55.14p PD=158.6u PS=157.1u ; M device
R168r 1 0 92k                            ; R device
C168s 1 3 381p                           ; C device
R168t 0 3 73k                            ; R device
R168u 0 2 696                            ; R device
C168v 0 2 4.1m                           ; C device
M168w 2 0 3 1 PMOS L=0.35u W=91.1u       ; M device
C168x 0 2 9.9u                           ; C device
R168y 0 3 69k                            ; R device
M168z 2 0 1 3 PMOS L=0.70u W=33.1u AD=27.42p AS=29.42p PD=85.7u PS=108.0u ; M device
C169a 2 1 347p                           ; C device
C169b 2 1 9p                             ; C device
M169c 2 0 1 3 PMOS L=0.25u W=15.6u       ; M device
C169d 3 0 7.4m                           ; C device
C169e 2 1 740p                           ; C device
C169f 0 2 276p                           ; C device
C169g 1 3 247p                           ; C device
R169h 2 0 2.6M                           ; R device
M169i 2 0 3 1 PMOS L=0.70u W=92.1u
+ AD=72.89p AS=66.74p PD=322.3u PS=197.0u ; M device
C169j 1 2 1.0u                           ; C device
C169k 2 3 73n                            ; C device
R169l 0 1 29k                            ; R device
C169m 3 1 0.3u                           ; C device
M169n 0 3 1 2 PMOS L=1.00u W=88.8u
+ AD=158.87p AS=114.92p PD=347.3u PS=291.6u ; M device
M169o 2 0 3 1 PMOS L=0.25u W=38.2u AD=58.49p AS=29.50p PD=132.7u PS=89.0u ; M device
R169p 1 3 31k                            ; R device
R169q 0 2 40                             ; R device
C169r 0 1 2.6u                           ; C device
R169s 1 0 118                            ; R device
C169t 0 3 13n                            ; C device
C169u 1 0 4.2m                           ; C device
R169v 2 3 55k                            ; R device
C169w 2 1 0.5m                           ; C device
C169x 1 3 2n                             ; C device
M169y 1 2 0 3 PMOS L=0.10u W=57.3u       ; M device
R169z 1 0 390                            ; R device
M170a 2 3 1 0 PMOS L=1.00u W=71.3u
+ AD=77.84p AS=14.24p PD=214.7u PS=249.0u ; M device
R170b 2 1 90                             ; R device
R170c 2 3 73k                            ; R device
M170d 0 3 1 2 PMOS L=0.18u W=67.4u       ; M device
R170e 0 2 7k                             ; R device
C170f 2 1 77n                            ; C device
M170g 2 1 0 3 PMOS L=0.18u W=79.3u       ; M device
M170h 1 0 3 2 PMOS L=0.50u W=99.7u       ; M device
C170i 0 1 923p                           ; C device
M170j 1 0 3 2 NMOS L=0.10u W=96.9u AD=11.15p AS=185.14p PD=364.8u PS=308.3u ; M device
M170k 2 3 0 1 NMOS L=0.35u W=7.0u AD=5.00p AS=10.88p PD=21.2u PS=22.2u ; M device
C170l 0 1 854p                           ; C device
R170m 0 2 701                            ; R device
M170n 2 0 1 3 PMOS L=0.13u W=4.3u AD=5.40p AS=1.98p PD=13.2u PS=16.6u ; M device
M170o 3 0 1 2 NMOS L=0.70u W=24.1u AD=17.57p AS=6.42p PD=75.9u PS=77.9u ; M device
C170p 3 0 54p                            ; C device
C170q 2 1 13n                            ; C device
R170r 1 3 8.3M                           ; R device
R170s 0 1 0.3M                           ; R device
R170t 1 3 485                            ; R device
R170u 3 2 13k                            ; R device
R170v 1 2 743                            ; R device
M170w 1 0 3 2 PMOS L=0.35u W=94.1u       ; M device
M170x 2 0 3 1 NMOS L=0.35u W=60.6u       ; M device
C170y 3 2 61n                            ; C device
R170z 2 1 358                            ; R device
C171a 3 2 18p                            ; C device
M171b 0 2 3 1 PMOS L=0.70u W=16.1u       ; M device
R171c 3 2 127                            ; R device
C171d 1 0 6.5u                           ; C device
M171e 1 3 2 0 NMOS L=0.35u W=70.7u AD=84.31p AS=12.41p PD=186.6u PS=181.2u ; M device
C171f 1 0 0.7u                           ; C device
R171g 2 1 80k                            ; R device
M171h 2 3 1 0 NMOS L=0.35u W=38.8u AD=59.64p AS=65.53p PD=128.7u PS=154.1u ; M device
C171i 2 0 1.1m                           ; C device
C171j 3 0 859p                           ; C device
M171k 1 2 3 0 NMOS L=0.13u W=71.4u       ; M device
C171l 3 2 904p                           ; C device
C171m 1 2 56n                            ; C device
M171n 0 3 2 1 PMOS L=0.70u W=79.1u AD=144.23p AS=91.30p PD=186.6u PS=311.1u ; M device
R171o 0 1 816                            ; R device
R171p 1 3 41k                            ; R device
R171q 0 1 66k                            ; R device
C171r 3 0 268p                           ; C device
R171s 3 1 4.9M                           ; R device
M171t 1 3 2 0 NMOS L=0.50u W=31.7u       ; M device
M171u 1 2 0 3 PMOS L=1.00u W=95.4u AD=86.83p AS=150.85p PD=347.2u PS=238.6u ; M device
C171v 3 2 8.6m                           ; C device
C171w 0 3 7.8u                           ; C device
C171x 2 0 56n                            ; C device
M171y 1 2 0 3 NMOS L=0.10u W=0.8u
+ AD=1.28p AS=0.70p PD=2.1u PS=2.9u ; M device
R171z 0 1 225                            ; R device
C172a 1 2 4n                             ; C device
M172b 0 2 1 3 PMOS L=0.25u W=47.2u       ; M device
M172c 1 2 0 3 NMOS L=0.70u W=58.4u AD=115.76p AS=77.85p PD=225.9u PS=128.3u ; M device
M172d 0 1 2 3 NMOS L=0.35u W=30.7u AD=12.39p AS=54.59p PD=70.3u PS=93.9u ; M device
C172e 0 2 721p                           ; C device
C172f 0 3 411p                           ; C device
R172g 3 0 53k                            ; R device
C172h 3 2 608p                           ; C device
C172i 1 3 74p                            ; C device
R172j 0 1 6.0M                           ; R device
R172k 3 2 81k                            ; R device
R172l 3 1 4k                             ; R device
M172m 2 1 3 0 NMOS L=0.10u W=16.0u       ; M device
C172n 0 3 0.3m                           ; C device
C172o 3 0 9.3u                           ; C device
C172p 1 3 111p                           ; C device
M172q 2 1 0 3 PMOS L=0.35u W=84.3u       ; M device
R172r 2 0 9.4M                           ; R device
R172s 2 0 2.2M                           ; R device
R172t 1 2 9.2M                           ; R device
R172u 1 3 132                            ; R device
M172v 0 3 2 1 NMOS L=0.25u W=55.1u       ; M device
M172w 2 3 1 0 PMOS L=1.00u W=66.2u       ; M device
M172x 0 1 2 3 NMOS L=0.13u W=8.9u        ; M device
R172y 3 2 4.9M                           ; R device
R172z 3 0 837                            ; R device
M173a 0 2 1 3 PMOS L=0.70u W=47.7u AD=40.65p AS=77.67p PD=152.2u PS=171.0u ; M device
M173b 3 0 1 2 NMOS L=0.10u W=89.3u       ; M device
R173c 2 0 4.6M                           ; R device
R173d 3 2 534                            ; R device
R173e 2 1 851                            ; R device
R173f 1 2 154                            ; R device
R173g 3 2 1.3M                           ; R device
M173h 2 0 3 1 NMOS L=0.35u W=26.7u AD=28.59p AS=27.40p PD=93.5u PS=61.1u ; M device
R173i 1 2 63k                            ; R device
C173j 2 1 97n                            ; C device
C173k 1 2 4.5m                           ; C device
M173l 0 3 2 1 NMOS L=0.35u W=79.4u       ; M device
M173m 2 1 0 3 NMOS L=0.18u W=44.4u       ; M device
M173n 0 1 2 3 PMOS L=0.35u W=59.8u AD=29.88p AS=16.87p PD=157.2u PS=178.6u ; M device
R173o 3 2 132                            ; R device
R173p 2 0 6.8M                           ; R device
C173q 2 0 3.2m                           ; C device
M173r 0 1 3 2 PMOS L=1.00u W=52.2u AD=79.56p AS=87.95p PD=135.2u PS=180.9u ; M device
M173s 0 3 2 1 NMOS L=0.35u W=12.3u
+ AD=9.63p AS=20.51p PD=24.8u PS=40.6u ; M device
R173t 0 3 421                            ; R device
C173u 3 0 809p                           ; C device
M173v 1 2 0 3 NMOS L=0.25u W=71.8u       ; M device
R173w 3 2 309                            ; R device
M173x 0 2 3 1 NMOS L=0.10u W=23.8u       ; M device
C173y 1 0 3.8u                           ; C device
R173z 3 0 151                            ; R device
M174a 2 1 0 3 NMOS L=0.18u W=50.2u       ; M device
C174b 2 1 3.5m                           ; C device
M174c 0 1 3 2 NMOS L=0.70u W=49.0u
+ AD=80.53p AS=64.94p PD=153.0u PS=188.8u ; M device
C174d 1 2 57n                            ; C device
R174e 1 0 8.6M                           ; R device
M174f 3 0 1 2 NMOS L=0.35u W=62.7u       ; M device
C174g 0 1 6.2u                           ; C device
M174h 1 0 2 3 PMOS L=0.13u W=90.5u       ; M device
R174i 0 3 0.6M                           ; R device
M174j 2 1 3 0 NMOS L=1.00u W=49.2u AD=6.03p AS=89.41p PD=185.4u PS=138.4u ; M device
R174k 1 0 9.4M                           ; R device
R174l 2 1 4.0M                           ; R device
C174m 0 3 629p                           ; C device
C174n 0 2 80n                            ; C device
R174o 0 3 9.6M                           ; R device
M174p 1 2 0 3 NMOS L=1.00u W=89.8u       ; M device
R174q 1 3 91k                            ; R device
R174r 0 3 29k                            ; R device
C174s 3 1 6.0u                           ; C device
R174t 0 2 57k                            ; R device
M174u 2 3 1 0 NMOS L=1.00u W=50.1u       ; M device
C174v 1 3 0.6u                           ; C device
C174w 3 2 8.4u                           ; C device
C174x 3 1 6.9u                           ; C device
C174y 1 2 35n                            ; C device
M174z 0 3 1 2 NMOS L=0.50u W=37.6u       ; M device
R175a 3 1 174                            ; R device
M175b 1 0 2 3 NMOS L=1.00u W=12.5u       ; M device
C175c 0 2 2.9u                           ; C device
R175d 1 3 849                            ; R device
C175e 2 1 75n                            ; C device
C175f 1 0 0.3u                           ; C device
C175g 1 2 47n                            ; C device
M175h 2 3 0 1 NMOS L=0.13u W=46.3u
+ AD=75.11p AS=86.86p PD=97.5u PS=137.6u ; M device
R175i 0 1 591                            ; R device
R175j 0 3 9k                             ; R device
R175k 1 0 709                            ; R device
R175l 3 0 310                            ; R device
M175m 0 3 1 2 NMOS L=0.50u W=65.4u       ; M device
C175n 2 1 5.6m                           ; C device
C175o 3 2 1.9m                           ; C device
R175p 3 0 73k                            ; R device
M175q 3 2 0 1 PMOS L=1.00u W=50.5u AD=23.41p AS=98.17p PD=157.3u PS=136.4u ; M device
M175r 2 0 1 3 PMOS L=0.50u W=93.2u       ; M device
M175s 0 2 1 3 NMOS L=0.50u W=6.5u
+ AD=10.03p AS=4.65p PD=16.6u PS=13.7u ; M device
R175t 3 2 65k                            ; R device
R175u 0 1 13k                            ; R device
M175v 1 0 3 2 PMOS L=0.35u W=94.4u AD=43.70p AS=67.80p PD=297.1u PS=223.1u ; M device
C175w 1 0 336p                           ; C device
C175x 1 0 2.9u                           ; C device
R175y 0 2 539                            ; R device
M175z 0 1 3 2 NMOS L=0.10u W=27.6u       ; M device
C176a 2 0 6.5u                           ; C device
R176b 1 3 1k                             ; R device
M176c 0 3 1 2 PMOS L=0.25u W=67.4u       ; M device
R176d 0 2 0.5M                           ; R device
M176e 0 1 2 3 PMOS L=0.35u W=30.8u       ; M device
M176f 3 1 2 0 NMOS L=0.13u W=51.1u
+ AD=84.68p AS=84.93p PD=175.7u PS=104.7u ; M device
C176g 1 2 318p                           ; C device
R176h 1 0 4.3M                           ; R device
R176i 3 1 10.0M                          ; R device
M176j 0 3 2 1 PMOS L=1.00u W=23.3u       ; M device
R176k 2 3 49k                            ; R device
R176l 3 0 85k                            ; R device
C176m 3 2 624p                           ; C device
M176n 1 2 3 0 NMOS L=0.25u W=47.3u       ; M device
R176o 2 1 34k                            ; R device
R176p 3 1 94k                            ; R device
C176q 3 0 745p                           ; C device
R176r 1 0 18k                            ; R device
R176s 1 0 211                            ; R device
M176t 3 0 1 2 PMOS L=1.00u W=69.5u
+ AD=10.47p AS=109.44p PD=266.2u PS=157.5u ; M device
R176u 3 2 28k                            ; R device
R176v 3 1 253                            ; R device
C176w 2 0 29p                            ; C device
C176x 0 2 5.0m                           ; C device
C176y 3 1 31n                            ; C device
R176z 0 2 91                             ; R device
R177a 2 1 1.5M                           ; R device
C177b 0 2 5p                             ; C device
M177c 1 2 0 3 PMOS L=0.50u W=24.6u
+ AD=32.97p AS=6.48p PD=65.1u PS=90.0u ; M device
R177d 2 0 685                            ; R device
C177e 0 1 7.5u                           ; C device
M177f 2 1 0 3 NMOS L=0.18u W=57.9u       ; M device
R177g 2 1 8k                             ; R device
C177h 3 0 7.4m                           ; C device
C177i 0 2 3.3m                           ; C device
R177j 1 0 2.1M                           ; R device
R177k 2 0 7.8M                           ; R device
R177l 3 2 269                            ; R device
R177m 1 0 8.6M                           ; R device
C177n 1 2 21n                            ; C device
M177o 1 0 2 3 NMOS L=0.70u W=52.6u       ; M device
C177p 2 0 626p                           ; C device
M177q 3 0 2 1 NMOS L=0.25u W=61.2u       ; M device
M177r 2 3 1 0 NMOS L=1.00u W=75.6u       ; M device
M177s 2 1 0 3 NMOS L=0.10u W=77.8u AD=20.15p AS=94.08p PD=265.0u PS=172.1u ; M device
C177t 2 3 667p                           ; C device
M177u 0 2 3 1 PMOS L=1.00u W=84.9u       ; M device
R177v 0 3 7k                             ; R device
R177w 1 2 155                            ; R device
C177x 0 2 297p                           ; C device
C177y 0 3 77n                            ; C device
R177z 0 2 130                            ; R device
C178a 1 3 788p                           ; C device
R178b 1 0 856                            ; R device
M178c 3 2 0 1 NMOS L=0.50u W=19.8u
+ AD=31.29p AS=22.95p PD=54.6u PS=77.0u ; M device
C178d 0 2 1.1m                           ; C device
C178e 3 0 251p                           ; C device
R178f 0 3 11k                            ; R device
C178g 3 2 680p                           ; C device
R178h 3 0 8.8M                           ; R device
C178i 3 0 610p                           ; C device
C178j 2 0 82n                            ; C device
R178k 3 0 9.6M                           ; R device
M178l 0 2 1 3 PMOS L=0.18u W=46.6u       ; M device
C178m 0 3 35n                            ; C device
C178n 3 1 21n                            ; C device
M178o 1 2 3 0 NMOS L=0.35u W=80.6u
+ AD=90.09p AS=96.89p PD=207.7u PS=193.1u ; M device
M178p 0 2 1 3 PMOS L=1.00u W=68.2u       ; M device
C178q 1 0 0.9u                           ; C device
C178r 3 1 3.5m                           ; C device
M178s 3 2 1 0 NMOS L=1.00u W=98.3u AD=16.29p AS=98.98p PD=373.6u PS=292.1u ; M device
C178t 0 3 25n                            ; C device
C178u 2 3 92n                            ; C device
M178v 2 1 0 3 PMOS L=0.10u W=14.7u       ; M device
M178w 0 3 1 2 NMOS L=0.70u W=11.7u AD=5.55p AS=14.69p PD=24.9u PS=29.9u ; M device
M178x 1 0 2 3 NMOS L=0.10u W=90.7u AD=28.19p AS=28.91p PD=298.1u PS=231.2u ; M device
M178y 0 3 2 1 PMOS L=0.35u W=72.3u
+ AD=138.19p AS=85.20p PD=220.4u PS=193.8u ; M device
C178z 2 0 26n                            ; C device
C179a 0 3 951p                           ; C device
R179b 3 1 341                            ; R device
C179c 1 3 364p                           ; C device
M179d 2 3 0 1 NMOS L=0.13u W=96.3u       ; M device
R179e 1 0 354                            ; R device
C179f 2 1 50n                            ; C device
C179g 2 0 93n                            ; C device
R179h 3 0 26k                            ; R device
C179i 1 0 35n                            ; C device
C179j 1 2 788p                           ; C device
R179k 1 0 790                            ; R device
R179l 0 1 2.6M                           ; R device
C179m 3 2 4.5m                           ; C device
C179n 1 0 860p                           ; C device
C179o 0 3 412p                           ; C device
M179p 3 0 2 1 PMOS L=0.35u W=32.1u       ; M device
M179q 1 2 3 0 NMOS L=0.35u W=45.6u
+ AD=58.65p AS=38.75p PD=181.6u PS=159.6u ; M device
R179r 1 0 6k                             ; R device
R179s 3 2 670                            ; R device
C179t 3 2 1.9m                           ; C device
C179u 3 1 2.0u                           ; C device
C179v 1 2 6.3m                           ; C device
C179w 1 3 56n                            ; C device
R179x 2 1 494                            ; R device
C179y 3 2 75n                            ; C device
R179z 2 1 83k                            ; R device
C180a 3 0 285p                           ; C device
R180b 2 0 3.8M                           ; R device
M180c 0 3 2 1 PMOS L=0.10u W=27.5u AD=50.66p AS=25.52p PD=89.8u PS=73.3u ; M device
M180d 3 2 1 0 PMOS L=0.13u W=61.7u
+ AD=36.91p AS=108.67p PD=214.4u PS=236.0u ; M device
R180e 0 2 81k                            ; R device
C180f 1 3 425p                           ; C device
R180g 1 2 574                            ; R device
R180h 2 1 384                            ; R device
C180i 3 2 902p                           ; C device
C180j 3 2 765p                           ; C device
M180k 3 2 0 1 NMOS L=0.70u W=26.5u       ; M device
R180l 3 2 783                            ; R device
C180m 0 2 623p                           ; C device
R180n 3 0 64k                            ; R device
C180o 3 1 84n                            ; C device
M180p 3 1 2 0 PMOS L=0.70u W=14.4u       ; M device
M180q 3 0 2 1 NMOS L=0.13u W=44.2u AD=43.44p AS=31.45p PD=89.2u PS=173.3u ; M device
M180r 3 0 1 2 PMOS L=0.10u W=75.4u
+ AD=148.81p AS=31.22p PD=273.2u PS=232.7u ; M device
M180s 1 2 3 0 PMOS L=0.50u W=5.2u AD=4.17p AS=6.81p PD=15.3u PS=20.0u ; M device
M180t 0 3 2 1 NMOS L=0.13u W=57.8u       ; M device
C180u 1 3 799p                           ; C device
M180v 3 2 0 1 PMOS L=0.10u W=10.3u
+ AD=12.38p AS=18.42p PD=38.3u PS=38.2u ; M device
C180w 2 1 3.9m                           ; C device
R180x 2 3 58k                            ; R device
R180y 1 3 2.5M                           ; R device
M180z 1 2 3 0 PMOS L=0.35u W=87.1u AD=48.19p AS=56.86p PD=333.6u PS=282.6u ; M device
M181a 3 2 0 1 PMOS L=0.35u W=89.2u AD=68.83p AS=17.12p PD=261.2u PS=333.0u ; M device
M181b 0 3 2 1 NMOS L=0.13u W=45.6u
+ AD=87.23p AS=26.35p PD=108.4u PS=125.1u ; M device
M181c 3 2 0 1 NMOS L=0.10u W=80.4u       ; M device
M181d 2 3 1 0 PMOS L=1.00u W=7.4u AD=13.24p AS=11.13p PD=23.9u PS=15.4u ; M device
M181e 3 0 2 1 PMOS L=1.00u W=50.8u       ; M device
C181f 1 0 7.7m                           ; C device
M181g 0 1 2 3 NMOS L=1.00u W=1.1u        ; M device
M181h 2 3 0 1 PMOS L=0.13u W=18.2u       ; M device
R181i 1 3 1000                           ; R device
C181j 2 0 266p                           ; C device
R181k 0 1 627                            ; R device
R181l 0 3 8.7M                           ; R device
C181m 3 0 83n                            ; C device
R181n 1 0 5.7M                           ; R device
C181o 1 2 6.6u                           ; C device
R181p 2 0 36k                            ; R device
M181q 1 0 3 2 PMOS L=0.70u W=59.9u
+ AD=19.88p AS=81.04p PD=157.5u PS=214.6u ; M device
R181r 3 1 7.9M                           ; R device
C181s 0 1 2.5u                           ; C device
R181t 3 2 39k                            ; R device
R181u 1 3 56k                            ; R device
M181v 1 2 3 0 NMOS L=0.70u W=85.6u       ; M device
R181w 1 2 781                            ; R device
M181x 2 0 3 1 NMOS L=0.18u W=11.5u       ; M device
R181y 2 3 71k                            ; R device
M181z 1 2 3 0 NMOS L=1.00u W=99.8u       ; M device
M182a 3 0 1 2 PMOS L=0.70u W=59.8u AD=15.61p AS=8.31p PD=120.6u PS=152.7u ; M device
M182b 1 3 0 2 NMOS L=0.70u W=41.8u AD=46.35p AS=56.42p PD=108.9u PS=96.0u ; M device
M182c 0 1 2 3 NMOS L=0.25u W=84.6u AD=26.26p AS=103.24p PD=293.5u PS=271.5u ; M device
M182d 3 2 1 0 NMOS L=0.25u W=91.5u       ; M device
M182e 2 0 3 1 NMOS L=0.18u W=22.4u       ; M device
R182f 0 3 149                            ; R device
M182g 3 2 1 0 PMOS L=0.35u W=14.4u
+ AD=2.80p AS=3.51p PD=38.5u PS=54.6u ; M device
R182h 3 1 3.8M                           ; R device
R182i 3 2 28k                            ; R device
M182j 0 3 2 1 PMOS L=0.50u W=17.6u
+ AD=11.48p AS=26.17p PD=55.5u PS=37.1u ; M device
C182k 0 1 6.2m                           ; C device
C182l 0 3 62n                            ; C device
R182m 0 2 8.3M                           ; R device
C182n 3 1 5.8u                           ; C device
R182o 2 1 5.1M                           ; R device
C182p 3 0 124p                           ; C device
M182q 3 0 1 2 NMOS L=0.10u W=24.4u       ; M device
R182r 1 3 661                            ; R device
R182s 1 3 79k                            ; R device
C182t 0 2 9n                             ; C device
M182u 1 3 2 0 NMOS L=0.10u W=92.5u AD=12.12p AS=163.95p PD=341.3u PS=296.4u ; M device
M182v 3 0 2 1 PMOS L=0.10u W=49.2u       ; M device
M182w 3 2 0 1 PMOS L=1.00u W=6.8u AD=7.91p AS=1.18p PD=14.1u PS=22.5u ; M device
C182x 1 0 9n                             ; C device
C182y 1 3 8.0u                           ; C device
M182z 0 1 3 2 NMOS L=0.50u W=22.4u AD=19.99p AS=14.18p PD=57.8u PS=68.6u ; M device
C183a 3 1 77p                            ; C device
R183b 3 1 87k                            ; R device
M183c 0 2 3 1 PMOS L=0.25u W=16.6u       ; M device
C183d 0 1 636p                           ; C device
C183e 3 0 885p                           ; C device
M183f 1 2 0 3 NMOS L=0.50u W=48.5u       ; M device
C183g 0 1 650p                           ; C device
R183h 3 0 62k                            ; R device
R183i 3 0 48k                            ; R device
C183j 3 2 4.7u                           ; C device
C183k 3 2 34n                            ; C device
C183l 2 0 35n                            ; C device
M183m 3 0 2 1 PMOS L=0.25u W=57.1u       ; M device
R183n 3 2 802                            ; R device
C183o 3 2 502p                           ; C device
C183p 3 1 9.2u                           ; C device
M183q 0 1 3 2 PMOS L=0.50u W=81.8u AD=90.78p AS=104.03p PD=266.8u PS=288.0u ; M device
R183r 2 0 8.0M                           ; R device
C183s 0 1 218p                           ; C device
C183t 2 1 59n                            ; C device
R183u 1 0 1.7M                           ; R device
M183v 2 1 3 0 NMOS L=0.13u W=93.3u       ; M device
R183w 2 3 338                            ; R device
M183x 1 0 3 2 NMOS L=1.00u W=28.8u       ; M device
M183y 3 2 0 1 NMOS L=0.18u W=83.3u
+ AD=63.25p AS=146.55p PD=263.9u PS=266.1u ; M device
R183z 0 3 6.6M                           ; R device
M184a 3 2 1 0 PMOS L=0.25u W=18.8u
+ AD=10.84p AS=35.15p PD=50.6u PS=42.1u ; M device
M184b 0 3 1 2 NMOS L=0.25u W=61.8u       ; M device
M184c 0 2 1 3 PMOS L=0.18u W=22.1u       ; M device
M184d 3 0 1 2 NMOS L=0.10u W=24.8u
+ AD=12.93p AS=38.50p PD=71.4u PS=61.8u ; M device
C184e 3 2 94n                            ; C device
R184f 2 1 9.0M                           ; R device
C184g 3 1 34n                            ; C device
C184h 2 1 746p                           ; C device
R184i 3 1 0.8M                           ; R device
C184j 0 3 979p                           ; C device
C184k 1 3 4.3m                           ; C device
C184l 3 0 11n                            ; C device
R184m 1 0 29k                            ; R device
C184n 3 0 2.7m                           ; C device
C184o 2 1 2.2m                           ; C device
M184p 3 1 0 2 PMOS L=0.35u W=50.5u       ; M device
C184q 1 0 56n                            ; C device
M184r 0 1 3 2 NMOS L=0.13u W=39.6u       ; M device
M184s 2 3 1 0 PMOS L=0.70u W=62.3u
+ AD=85.69p AS=48.14p PD=156.5u PS=126.3u ; M device
M184t 2 0 3 1 PMOS L=0.70u W=83.1u
+ AD=54.66p AS=93.68p PD=266.4u PS=302.1u ; M device
M184u 3 2 0 1 NMOS L=0.25u W=36.5u       ; M device
R184v 1 0 3.2M                           ; R device
R184w 1 2 7.0M                           ; R device
R184x 2 1 13k                            ; R device
R184y 0 2 36k                            ; R device
R184z 1 3 5k                             ; R device
M185a 1 2 3 0 PMOS L=0.25u W=28.0u
+ AD=40.12p AS=11.63p PD=80.5u PS=83.2u ; M device
R185b 3 0 2.4M                           ; R device
C185c 0 3 69n                            ; C device
M185d 0 3 2 1 PMOS L=0.18u W=57.9u
+ AD=101.90p AS=70.31p PD=156.8u PS=147.7u ; M device
C185e 0 3 164p                           ; C device
C185f 0 1 15n                            ; C device
M185g 3 1 2 0 PMOS L=0.50u W=40.4u
+ AD=34.93p AS=76.13p PD=103.3u PS=130.4u ; M device
R185h 2 3 3.6M                           ; R device
M185i 0 2 3 1 NMOS L=0.25u W=62.9u       ; M device
M185j 3 2 1 0 PMOS L=0.70u W=89.9u
+ AD=116.55p AS=122.30p PD=182.9u PS=229.5u ; M device
R185k 2 3 9.0M                           ; R device
M185l 3 1 2 0 PMOS L=0.10u W=9.8u
+ AD=11.02p AS=2.62p PD=32.2u PS=27.7u ; M device
C185m 2 1 8.2m                           ; C device
R185n 3 1 2.3M                           ; R device
R185o 3 0 9.9M                           ; R device
C185p 0 2 5.4u                           ; C device
R185q 2 3 80k                            ; R device
R185r 2 1 654                            ; R device
R185s 1 0 50k                            ; R device
M185t 3 2 1 0 PMOS L=0.35u W=91.0u AD=65.57p AS=114.59p PD=217.6u PS=342.0u ; M device
M185u 1 0 3 2 PMOS L=0.18u W=91.1u       ; M device
C185v 0 2 7.1u                           ; C device
C185w 3 0 5.3u                           ; C device
R185x 1 0 3.3M                           ; R device
R185y 0 1 76k                            ; R device
C185z 2 3 4.0u                           ; C device
C186a 3 0 7.1m                           ; C device
M186b 3 2 1 0 PMOS L=1.00u W=98.0u       ; M device
R186c 3 2 45                             ; R device
R186d 3 2 856                            ; R device
C186e 3 2 7.9u                           ; C device
M186f 2 1 3 0 PMOS L=0.70u W=30.4u
+ AD=54.66p AS=51.97p PD=68.5u PS=96.0u ; M device
C186g 3 0 580p                           ; C device
C186h 3 1 8.9u                           ; C device
R186i 0 3 8.1M                           ; R device
R186j 0 2 506                            ; R device
M186k 2 1 3 0 PMOS L=0.13u W=14.1u AD=20.16p AS=4.09p PD=32.6u PS=44.6u ; M device
C186l 0 2 9p                             ; C device
M186m 1 2 0 3 NMOS L=1.00u W=15.2u AD=7.15p AS=26.62p PD=40.3u PS=49.6u ; M device
C186n 3 1 741p                           ; C device
M186o 0 3 1 2 PMOS L=0.25u W=36.2u       ; M device
M186p 1 3 2 0 NMOS L=0.13u W=54.6u AD=21.51p AS=21.60p PD=173.1u PS=141.7u ; M device
R186q 3 0 16k                            ; R device
M186r 3 2 0 1 NMOS L=1.00u W=23.0u AD=8.31p AS=34.88p PD=83.3u PS=90.4u ; M device
M186s 3 2 1 0 PMOS L=1.00u W=23.6u AD=37.67p AS=6.74p PD=71.7u PS=63.8u ; M device
R186t 0 1 207                            ; R device
M186u 3 1 0 2 NMOS L=0.35u W=40.3u AD=53.31p AS=26.92p PD=86.5u PS=86.9u ; M device
C186v 3 0 3.8m                           ; C device
M186w 1 0 3 2 PMOS L=0.10u W=72.6u
+ AD=12.53p AS=121.57p PD=219.5u PS=242.0u ; M device
M186x 3 0 1 2 NMOS L=0.10u W=17.2u
+ AD=32.89p AS=11.24p PD=44.9u PS=39.7u ; M device
C186y 3 0 9.6m                           ; C device
R186z 3 2 57k                            ; R device
M187a 2 3 1 0 PMOS L=0.18u W=69.3u       ; M device
C187b 3 0 3n                             ; C device
M187c 1 3 2 0 PMOS L=1.00u W=91.9u
+ AD=163.27p AS=97.27p PD=215.8u PS=305.0u ; M device
R187d 3 1 540                            ; R device
R187e 1 3 30k                            ; R device
C187f 2 1 4.8u                           ; C device
C187g 2 3 2.3m                           ; C device
R187h 0 2 26k                            ; R device
M187i 1 0 3 2 PMOS L=0.50u W=55.0u       ; M device
R187j 0 2 66k                            ; R device
M187k 0 3 1 2 NMOS L=0.35u W=51.8u
+ AD=54.44p AS=93.55p PD=174.3u PS=184.9u ; M device
C187l 3 2 3.5m                           ; C device
R187m 0 1 8.2M                           ; R device
M187n 0 1 3 2 PMOS L=0.35u W=31.3u       ; M device
R187o 1 2 2k                             ; R device
M187p 3 2 1 0 PMOS L=0.18u W=99.1u AD=61.90p AS=148.07p PD=266.6u PS=275.0u ; M device
C187q 1 2 710p                           ; C device
C187r 2 1 5.6m                           ; C device
R187s 3 1 45k                            ; R device
C187t 0 3 0.6m                           ; C device
C187u 0 2 567p                           ; C device
C187v 2 1 504p                           ; C device
R187w 0 3 9.4M                           ; R device
M187x 0 2 3 1 NMOS L=0.13u W=44.3u       ; M device
R187y 0 1 36k                            ; R device
M187z 1 0 3 2 PMOS L=0.70u W=79.3u AD=90.18p AS=90.25p PD=174.2u PS=186.2u ; M device
M188a 3 2 1 0 PMOS L=0.10u W=86.5u       ; M device
C188b 0 2 33n                            ; C device
C188c 2 3 7.8m                           ; C device
C188d 2 3 8.6m                           ; C device
R188e 2 3 5.4M                           ; R device
M188f 2 0 1 3 PMOS L=0.70u W=36.6u
+ AD=45.37p AS=5.55p PD=115.2u PS=83.2u ; M device
C188g 0 1 39n                            ; C device
M188h 0 2 3 1 NMOS L=0.13u W=5.4u        ; M device
M188i 2 0 1 3 NMOS L=0.50u W=21.9u       ; M device
M188j 3 0 1 2 PMOS L=0.13u W=5.8u        ; M device
C188k 1 2 6.9m                           ; C device
C188l 2 3 2.0u                           ; C device
C188m 0 3 16p                            ; C device
C188n 3 0 63n                            ; C device
R188o 0 2 200                            ; R device
M188p 0 3 1 2 PMOS L=0.50u W=42.6u       ; M device
C188q 0 1 124p                           ; C device
R188r 2 0 524                            ; R device
M188s 0 3 1 2 NMOS L=1.00u W=79.7u AD=8.53p AS=47.02p PD=260.1u PS=190.3u ; M device
R188t 0 2 26                             ; R device
M188u 3 2 0 1 NMOS L=0.70u W=85.1u       ; M device
M188v 0 3 1 2 PMOS L=0.70u W=59.5u
+ AD=52.83p AS=20.66p PD=139.4u PS=191.8u ; M device
M188w 1 0 3 2 NMOS L=0.25u W=90.6u AD=92.20p AS=53.94p PD=360.5u PS=185.8u ; M device
M188x 1 3 0 2 PMOS L=0.25u W=63.7u AD=26.76p AS=75.25p PD=210.4u PS=176.9u ; M device
C188y 2 0 2.4u                           ; C device
C188z 1 0 6.6m                           ; C device
C189a 3 2 8.9u                           ; C device
R189b 0 3 995                            ; R device
R189c 2 3 46                             ; R device
C189d 0 1 91n                            ; C device
R189e 3 2 25k                            ; R device
C189f 3 0 12n                            ; C device
R189g 3 1 85k                            ; R device
C189h 3 0 989p                           ; C device
C189i 3 2 8.8m                           ; C device
C189j 3 1 7.2u                           ; C device
C189k 0 2 544p                           ; C device
C189l 1 0 1.8u                           ; C device
R189m 1 0 3.0M                           ; R device
M189n 3 1 0 2 PMOS L=0.18u W=46.7u       ; M device
R189o 0 1 424                            ; R device
C189p 2 3 7.8u                           ; C device
R189q 1 0 121                            ; R device
R189r 3 2 75k                            ; R device
C189s 0 2 84n                            ; C device
C189t 3 2 0.9u                           ; C device
M189u 2 1 3 0 NMOS L=1.00u W=79.7u       ; M device
R189v 2 0 4.9M                           ; R device
R189w 1 0 344                            ; R device
C189x 3 1 0.6u                           ; C device
M189y 1 3 0 2 NMOS L=0.13u W=93.8u       ; M device
R189z 0 3 174                            ; R device
R190a 2 1 86k                            ; R device
M190b 1 2 0 3 NMOS L=0.70u W=53.6u       ; M device
M190c 3 0 1 2 PMOS L=0.13u W=20.4u       ; M device
R190d 0 2 24k                            ; R device
M190e 2 3 1 0 NMOS L=0.70u W=16.7u       ; M device
M190f 2 0 3 1 NMOS L=0.13u W=14.6u       ; M device
R190g 0 3 395                            ; R device
M190h 2 1 3 0 NMOS L=0.70u W=4.2u
+ AD=0.94p AS=1.02p PD=11.0u PS=13.8u ; M device
C190i 2 1 72n                            ; C device
M190j 2 1 3 0 PMOS L=0.25u W=67.8u
+ AD=57.41p AS=51.95p PD=246.1u PS=247.0u ; M device
R190k 1 0 8k                             ; R device
C190l 3 2 6.0m                           ; C device
C190m 1 0 19n                            ; C device
M190n 1 3 0 2 NMOS L=0.10u W=6.4u        ; M device
M190o 0 3 1 2 PMOS L=1.00u W=23.8u
+ AD=10.82p AS=31.91p PD=71.9u PS=52.3u ; M device
C190p 1 2 758p                           ; C device
M190q 3 1 2 0 NMOS L=0.25u W=84.1u       ; M device
M190r 0 3 2 1 NMOS L=0.70u W=86.4u
+ AD=80.80p AS=110.04p PD=288.5u PS=301.3u ; M device
C190s 2 0 579p                           ; C device
M190t 3 2 1 0 NMOS L=0.10u W=7.5u
+ AD=8.46p AS=13.01p PD=26.0u PS=18.2u ; M device
M190u 1 3 0 2 PMOS L=0.25u W=20.3u       ; M device
R190v 2 1 35                             ; R device
M190w 3 1 2 0 PMOS L=0.25u W=91.3u
+ AD=36.85p AS=119.22p PD=196.3u PS=355.8u ; M device
R190x 0 3 100                            ; R device
C190y 1 0 8.2u                           ; C device
M190z 2 3 1 0 PMOS L=0.10u W=22.3u AD=28.14p AS=39.38p PD=76.3u PS=54.3u ; M device
R191a 0 1 708                            ; R device
R191b 2 0 951                            ; R device
C191c 1 0 257p                           ; C device
M191d 2 3 0 1 PMOS L=0.25u W=6.2u        ; M device
R191e 2 3 1k                             ; R device
R191f 2 1 0.8M                           ; R device
C191g 3 2 99n                            ; C device
R191h 0 3 5.9M                           ; R device
C191i 2 3 1.8u                           ; C device
R191j 0 1 598                            ; R device
R191k 2 1 30k                            ; R device
C191l 2 3 43n                            ; C device
M191m 0 3 2 1 NMOS L=1.00u W=87.5u AD=115.96p AS=92.29p PD=193.6u PS=175.9u ; M device
C191n 3 2 8.9u                           ; C device
R191o 3 0 34k                            ; R device
M191p 3 0 2 1 NMOS L=0.70u W=40.6u AD=77.13p AS=5.13p PD=101.3u PS=139.8u ; M device
M191q 0 2 1 3 NMOS L=0.18u W=0.5u AD=0.14p AS=0.10p PD=1.7u PS=1.1u ; M device
C191r 0 1 88n                            ; C device
C191s 0 2 6.2u                           ; C device
R191t 1 0 706                            ; R device
C191u 3 2 3n                             ; C device
M191v 1 0 3 2 PMOS L=0.10u W=87.7u       ; M device
M191w 0 1 3 2 PMOS L=1.00u W=25.2u       ; M device
R191x 1 3 38                             ; R device
M191y 2 1 3 0 NMOS L=0.18u W=46.3u AD=44.57p AS=41.32p PD=153.2u PS=129.4u ; M device
C191z 1 3 5.0u                           ; C device
M192a 0 2 3 1 NMOS L=0.10u W=50.2u
+ AD=85.20p AS=74.54p PD=104.1u PS=185.4u ; M device
M192b 3 0 1 2 PMOS L=0.18u W=84.2u AD=150.27p AS=131.51p PD=188.6u PS=267.6u ; M device
C192c 0 2 0.3u                           ; C device
R192d 2 0 81k                            ; R device
C192e 2 1 91n                            ; C device
M192f 2 1 3 0 NMOS L=1.00u W=78.0u AD=154.89p AS=93.74p PD=218.0u PS=274.1u ; M device
R192g 2 3 6.9M                           ; R device
R192h 2 0 44k                            ; R device
R192i 2 1 61k                            ; R device
R192j 1 0 40k                            ; R device
C192k 2 1 1.7m                           ; C device
C192l 3 2 142p                           ; C device
C192m 1 2 31n                            ; C device
R192n 0 2 8.1M                           ; R device
M192o 0 3 2 1 NMOS L=0.50u W=78.8u
+ AD=24.16p AS=91.80p PD=245.9u PS=183.1u ; M device
R192p 2 1 7k                             ; R device
C192q 0 3 4.3u                           ; C device
C192r 0 3 91n                            ; C device
C192s 2 1 25n                            ; C device
R192t 3 0 61k                            ; R device
C192u 1 2 53n                            ; C device
R192v 1 3 28k                            ; R device
C192w 2 3 9.3m                           ; C device
R192x 1 2 5.1M                           ; R device
M192y 0 2 1 3 NMOS L=0.50u W=36.8u
+ AD=47.69p AS=40.46p PD=142.3u PS=140.0u ; M device
R192z 1 0 27k                            ; R device
R193a 3 1 928                            ; R device
M193b 3 1 2 0 NMOS L=0.70u W=5.1u        ; M device
C193c 0 2 963p                           ; C device
R193d 0 2 132                            ; R device
M193e 0 2 1 3 NMOS L=0.25u W=3.9u
+ AD=2.41p AS=2.12p PD=7.9u PS=11.8u ; M device
C193f 1 3 4.9m                           ; C device
R193g 1 0 773                            ; R device
M193h 1 3 2 0 NMOS L=0.25u W=28.2u       ; M device
R193i 2 0 805                            ; R device
M193j 3 1 0 2 NMOS L=0.13u W=21.6u
+ AD=19.86p AS=32.01p PD=73.7u PS=47.5u ; M device
M193k 2 0 1 3 NMOS L=0.50u W=31.8u       ; M device
R193l 2 0 4.4M                           ; R device
C193m 2 3 5.7u                           ; C device
R193n 1 3 3.7M                           ; R device
R193o 1 3 9.5M                           ; R device
M193p 2 3 0 1 PMOS L=0.10u W=6.6u AD=2.02p AS=11.67p PD=18.2u PS=18.4u ; M device
C193q 3 0 497p                           ; C device
C193r 2 0 1.3u                           ; C device
R193s 2 1 4.9M                           ; R device
R193t 1 2 276                            ; R device
C193u 0 2 7.3u                           ; C device
M193v 0 1 3 2 NMOS L=0.13u W=50.8u AD=82.90p AS=75.79p PD=131.6u PS=173.4u ; M device
R193w 1 3 55                             ; R device
M193x 2 3 0 1 NMOS L=0.13u W=32.4u       ; M device
R193y 0 2 78k                            ; R device
R193z 1 0 7.2M                           ; R device
R194a 1 0 1.2M                           ; R device
R194b 3 1 9.4M                           ; R device
R194c 3 2 444                            ; R device
C194d 0 1 4.8m                           ; C device
R194e 2 3 4k                             ; R device
R194f 1 2 8.5M                           ; R device
M194g 0 2 3 1 NMOS L=0.25u W=77.3u AD=19.04p AS=48.02p PD=285.0u PS=291.1u ; M device
C194h 0 2 20n                            ; C device
R194i 2 1 40k                            ; R device
R194j 3 1 946                            ; R device
M194k 0 2 1 3 PMOS L=0.13u W=30.3u AD=34.70p AS=28.50p PD=82.6u PS=94.9u ; M device
R194l 3 2 124                            ; R device
M194m 1 2 0 3 PMOS L=0.70u W=23.6u       ; M device
C194n 0 3 808p                           ; C device
R194o 2 0 5.4M                           ; R device
C194p 0 3 7.3m                           ; C device
M194q 3 2 0 1 NMOS L=1.00u W=26.9u AD=48.88p AS=49.62p PD=71.3u PS=68.1u ; M device
M194r 1 0 3 2 NMOS L=0.10u W=50.4u       ; M device
C194s 2 3 4.2m                           ; C device
M194t 1 0 2 3 PMOS L=0.70u W=95.4u AD=18.86p AS=25.38p PD=329.6u PS=376.6u ; M device
M194u 1 2 0 3 PMOS L=0.25u W=73.5u AD=46.45p AS=7.56p PD=189.7u PS=215.9u ; M device
M194v 3 2 0 1 NMOS L=0.50u W=75.3u AD=96.00p AS=93.59p PD=270.7u PS=273.5u ; M device
C194w 0 2 804p                           ; C device
C194x 2 1 4.8u                           ; C device
C194y 2 3 188p                           ; C device
C194z 1 3 46n                            ; C device
R195a 2 1 52k                            ; R device
M195b 1 0 2 3 PMOS L=0.13u W=32.7u
+ AD=25.83p AS=53.93p PD=126.2u PS=110.3u ; M device
C195c 0 3 1.8m                           ; C device
R195d 1 2 450                            ; R device
C195e 2 3 5.9u                           ; C device
R195f 1 3 95k                            ; R device
M195g 0 2 1 3 NMOS L=0.13u W=41.8u       ; M device
C195h 0 3 8.8m                           ; C device
C195i 2 1 7.6u                           ; C device
C195j 0 2 5.6u                           ; C device
R195k 2 3 8.7M                           ; R device
C195l 0 1 6.4u                           ; C device
R195m 3 0 6.4M                           ; R device
R195n 0 1 8.1M                           ; R device
R195o 2 0 43k                            ; R device
R195p 1 0 20k                            ; R device
C195q 0 1 34n                            ; C device
C195r 3 2 893p                           ; C device
R195s 2 0 50k                            ; R device
R195t 3 0 932                            ; R device
M195u 0 2 3 1 NMOS L=0.13u W=61.8u AD=36.52p AS=36.04p PD=147.3u PS=209.1u ; M device
M195v 3 1 0 2 PMOS L=0.13u W=90.8u       ; M device
R195w 3 0 31k                            ; R device
R195x 1 3 90k                            ; R device
R195y 1 0 10k                            ; R device
C195z 0 2 8.8u                           ; C device
R196a 0 1 5.8M                           ; R device
C196b 1 2 633p                           ; C device
R196c 2 3 88k                            ; R device
R196d 0 2 4k                             ; R device
M196e 2 3 1 0 NMOS L=0.18u W=50.3u       ; M device
R196f 2 1 168                            ; R device
C196g 2 3 87p                            ; C device
C196h 3 1 541p                           ; C device
C196i 3 0 747p                           ; C device
M196j 0 1 3 2 NMOS L=0.25u W=62.2u AD=12.48p AS=52.82p PD=241.4u PS=126.0u ; M device
R196k 0 3 83k                            ; R device
M196l 2 3 1 0 NMOS L=0.50u W=51.8u       ; M device
M196m 3 1 2 0 PMOS L=0.50u W=72.2u AD=92.16p AS=102.52p PD=158.7u PS=272.3u ; M device
R196n 3 1 8.5M                           ; R device
C196o 0 2 867p                           ; C device
C196p 3 2 545p                           ; C device
M196q 0 1 3 2 PMOS L=0.50u W=79.2u
+ AD=100.81p AS=93.62p PD=222.3u PS=186.6u ; M device
C196r 2 3 93n                            ; C device
R196s 3 2 71                             ; R device
M196t 0 3 1 2 PMOS L=0.25u W=39.3u AD=16.58p AS=32.08p PD=138.8u PS=101.3u ; M device
M196u 0 1 3 2 PMOS L=0.18u W=63.9u AD=25.94p AS=10.99p PD=146.6u PS=193.9u ; M device
C196v 2 0 3.9u                           ; C device
R196w 3 0 75k                            ; R device
C196x 2 0 748p                           ; C device
M196y 2 1 0 3 NMOS L=0.35u W=34.5u
+ AD=37.16p AS=63.64p PD=125.4u PS=96.0u ; M device
R196z 1 3 6.1M                           ; R device
R197a 1 0 6.1M                           ; R device
M197b 2 1 0 3 NMOS L=0.25u W=23.4u
+ AD=28.34p AS=14.36p PD=50.6u PS=49.5u ; M device
C197c 3 0 677p                           ; C device
R197d 0 2 54k                            ; R device
C197e 3 2 51n                            ; C device
C197f 2 0 7.0m                           ; C device
R197g 2 0 9.5M                           ; R device
R197h 3 2 2.8M                           ; R device
R197i 0 3 95                             ; R device
C197j 2 1 3.8u                           ; C device
R197k 3 0 921                            ; R device
M197l 0 2 3 1 NMOS L=0.25u W=1.5u        ; M device
C197m 0 2 7.3u                           ; C device
M197n 1 0 3 2 PMOS L=0.70u W=85.3u       ; M device
C197o 0 3 2.5u                           ; C device
M197p 2 3 1 0 NMOS L=0.25u W=55.9u AD=85.66p AS=72.61p PD=188.8u PS=135.1u ; M device
M197q 2 1 3 0 PMOS L=1.00u W=51.7u       ; M device
M197r 1 3 2 0 PMOS L=0.18u W=50.4u       ; M device
R197s 0 2 3.6M                           ; R device
C197t 1 2 2.7m                           ; C device
C197u 0 2 0.8m                           ; C device
M197v 1 2 0 3 NMOS L=0.50u W=74.4u
+ AD=71.80p AS=100.66p PD=199.7u PS=244.1u ; M device
M197w 2 0 3 1 NMOS L=0.35u W=48.5u       ; M device
M197x 0 1 2 3 NMOS L=0.13u W=51.5u       ; M device
C197y 1 0 6.5m                           ; C device
C197z 1 0 298p                           ; C device
M198a 3 0 2 1 NMOS L=0.25u W=45.0u       ; M device
C198b 3 2 49n                            ; C device
C198c 0 2 1.5u                           ; C device
M198d 2 3 0 1 NMOS L=0.18u W=77.8u
+ AD=136.80p AS=12.03p PD=255.1u PS=256.8u ; M device
R198e 3 2 4.9M                           ; R device
R198f 2 3 2.9M                           ; R device
M198g 3 2 0 1 NMOS L=0.13u W=6.5u        ; M device
R198h 3 2 633                            ; R device
R198i 3 0 20k                            ; R device
C198j 1 0 18n                            ; C device
C198k 3 2 88p                            ; C device
C198l 1 3 6.5m                           ; C device
R198m 0 1 21k                            ; R device
M198n 2 0 3 1 PMOS L=0.18u W=79.7u AD=41.71p AS=20.97p PD=300.6u PS=253.8u ; M device
M198o 0 1 3 2 NMOS L=0.50u W=24.1u
+ AD=46.55p AS=23.09p PD=55.6u PS=96.0u ; M device
C198p 2 0 9.9m                           ; C device
R198q 2 1 2.4M                           ; R device
M198r 0 3 2 1 PMOS L=1.00u W=63.0u
+ AD=73.29p AS=40.16p PD=148.8u PS=152.2u ; M device
M198s 0 2 1 3 PMOS L=0.18u W=92.5u       ; M device
C198t 0 2 5.2m                           ; C device
R198u 2 3 1.5M                           ; R device
R198v 0 1 8.4M                           ; R device
R198w 1 2 8.2M                           ; R device
M198x 1 2 0 3 NMOS L=0.35u W=57.7u       ; M device
M198y 0 2 3 1 PMOS L=1.00u W=34.4u       ; M device
R198z 2 3 6.5M                           ; R device
R199a 3 1 292                            ; R device
C199b 3 2 10n                            ; C device
R199c 2 0 353                            ; R device
C199d 3 2 3.8m                           ; C device
M199e 1 0 2 3 PMOS L=0.70u W=88.0u       ; M device
M199f 3 1 0 2 PMOS L=1.00u W=88.0u       ; M device
M199g 0 3 1 2 NMOS L=1.00u W=90.4u       ; M device
M199h 3 1 2 0 PMOS L=0.10u W=59.6u       ; M device
M199i 0 3 2 1 NMOS L=0.25u W=55.1u AD=38.76p AS=56.24p PD=206.8u PS=133.9u ; M device
C199j 0 1 7.3u                           ; C device
M199k 3 1 2 0 PMOS L=0.25u W=47.3u
+ AD=77.24p AS=56.32p PD=163.8u PS=154.9u ; M device
M199l 1 2 0 3 NMOS L=0.18u W=55.2u       ; M device
M199m 2 0 3 1 PMOS L=0.10u W=47.4u       ; M device
M199n 3 0 2 1 NMOS L=0.10u W=66.4u AD=34.54p AS=122.24p PD=181.7u PS=198.2u ; M device
R199o 3 2 711                            ; R device
C199p 2 0 663p                           ; C device
M199q 1 3 2 0 PMOS L=1.00u W=51.0u AD=58.51p AS=78.87p PD=178.9u PS=195.2u ; M device
R199r 0 2 853                            ; R device
C199s 1 3 8.5u                           ; C device
R199t 1 0 482                            ; R device
R199u 3 1 4.5M                           ; R device
M199v 0 1 3 2 PMOS L=0.25u W=27.3u
+ AD=42.76p AS=12.61p PD=57.8u PS=93.5u ; M device
C199w 3 2 69n                            ; C device
M199x 0 1 3 2 PMOS L=0.18u W=80.2u       ; M device
M199y 3 2 1 0 NMOS L=0.25u W=98.7u
+ AD=138.98p AS=98.43p PD=292.4u PS=284.6u ; M device
C199z 2 3 654p                           ; C device
M200a 2 3 1 0 NMOS L=0.13u W=44.3u
+ AD=79.42p AS=74.90p PD=121.2u PS=109.1u ; M device
M200b 3 0 1 2 NMOS L=1.00u W=32.7u
+ AD=49.80p AS=31.35p PD=120.1u PS=67.8u ; M device
R200c 2 0 64k                            ; R device
R200d 3 0 4.2M                           ; R device
M200e 0 2 3 1 NMOS L=0.10u W=11.7u
+ AD=11.87p AS=8.19p PD=25.9u PS=40.3u ; M device
R200f 0 1 9.2M                           ; R device
R200g 3 1 1.1M                           ; R device
R200h 1 2 22k                            ; R device
C200i 1 0 129p                           ; C device
C200j 1 2 8.4m                           ; C device
M200k 0 1 3 2 NMOS L=0.13u W=48.8u AD=43.13p AS=89.40p PD=113.5u PS=102.8u ; M device
C200l 0 2 25n                            ; C device
R200m 2 0 3.4M                           ; R device
M200n 2 3 1 0 PMOS L=0.70u W=71.1u       ; M device
M200o 0 2 1 3 PMOS L=0.25u W=90.5u
+ AD=138.46p AS=69.57p PD=322.7u PS=283.0u ; M device
C200p 1 0 655p                           ; C device
R200q 0 2 55k                            ; R device
C200r 2 0 127p                           ; C device
C200s 2 3 6.0m                           ; C device
C200t 0 2 6.8m                           ; C device
R200u 1 2 0.2M                           ; R device
C200v 0 3 0.9u                           ; C device
M200w 0 1 2 3 PMOS L=0.13u W=75.3u       ; M device
R200x 2 3 47k                            ; R device
R200y 3 1 100k                           ; R device
R200z 0 1 152                            ; R device
M201a 3 1 2 0 PMOS L=0.10u W=75.5u       ; M device
M201b 1 3 2 0 PMOS L=0.18u W=93.9u       ; M device
C201c 0 1 91n                            ; C device
R201d 2 1 430                            ; R device
M201e 1 2 3 0 NMOS L=0.35u W=13.6u       ; M device
C201f 2 1 1.1m                           ; C device
M201g 2 0 3 1 PMOS L=0.13u W=48.1u       ; M device
C201h 3 0 1.4u                           ; C device
C201i 0 1 6n                             ; C device
R201j 2 0 62k                            ; R device
M201k 3 2 1 0 PMOS L=1.00u W=42.8u       ; M device
C201l 2 1 725p                           ; C device
C201m 3 1 1.2u                           ; C device
C201n 2 3 35n                            ; C device
R201o 0 3 4k                             ; R device
M201p 2 0 1 3 NMOS L=0.13u W=18.3u AD=11.11p AS=18.77p PD=49.0u PS=62.3u ; M device
R201q 3 1 57k                            ; R device
R201r 1 3 57k                            ; R device
R201s 3 1 68k                            ; R device
M201t 3 0 2 1 PMOS L=0.10u W=2.3u AD=1.68p AS=2.47p PD=4.9u PS=7.9u ; M device
R201u 1 0 5.0M                           ; R device
R201v 3 0 139                            ; R device
R201w 1 0 392                            ; R device
M201x 0 3 1 2 NMOS L=0.70u W=21.6u AD=5.85p AS=10.30p PD=55.3u PS=66.6u ; M device
C201y 2 0 665p                           ; C device
C201z 3 2 9.7u                           ; C device
M202a 3 2 0 1 PMOS L=0.70u W=26.8u AD=6.51p AS=33.98p PD=80.6u PS=102.2u ; M device
M202b 3 0 2 1 PMOS L=0.13u W=83.0u AD=88.33p AS=23.88p PD=239.3u PS=182.0u ; M device
C202c 3 1 81n                            ; C device
R202d 3 0 77k                            ; R device
R202e 2 1 80k                            ; R device
R202f 1 0 9.9M                           ; R device
C202g 0 2 1.8u                           ; C device
C202h 0 1 0.5m                           ; C device
C202i 0 3 722p                           ; C device
R202j 3 0 28k                            ; R device
C202k 0 2 2.3u                           ; C device
M202l 0 1 2 3 PMOS L=0.13u W=61.5u       ; M device
C202m 3 1 757p                           ; C device
M202n 0 3 1 2 NMOS L=0.13u W=73.4u
+ AD=18.63p AS=71.19p PD=188.1u PS=196.1u ; M device
R202o 1 3 7.6M                           ; R device
R202p 3 1 8.4M                           ; R device
C202q 0 2 9.9m                           ; C device
C202r 1 0 83n                            ; C device
C202s 2 3 638p                           ; C device
R202t 0 2 248                            ; R device
M202u 0 2 1 3 NMOS L=0.25u W=51.3u       ; M device
R202v 3 2 100k                           ; R device
C202w 1 2 88n                            ; C device
R202x 3 1 840                            ; R device
M202y 2 3 1 0 PMOS L=0.13u W=17.7u
+ AD=13.06p AS=20.28p PD=47.3u PS=57.5u ; M device
C202z 0 2 77n                            ; C device
R203a 2 0 691                            ; R device
R203b 1 3 453                            ; R device
M203c 3 1 0 2 PMOS L=0.25u W=21.2u AD=26.45p AS=12.55p PD=43.2u PS=76.5u ; M device
M203d 0 1 2 3 PMOS L=0.70u W=47.6u       ; M device
M203e 2 0 3 1 NMOS L=0.18u W=23.4u
+ AD=15.45p AS=37.41p PD=56.8u PS=56.5u ; M device
C203f 0 3 4.2m                           ; C device
R203g 1 0 949                            ; R device
R203h 2 1 826                            ; R device
M203i 3 1 0 2 NMOS L=0.25u W=83.2u       ; M device
R203j 2 0 5.5M                           ; R device
C203k 2 0 42n                            ; C device
M203l 3 0 1 2 NMOS L=0.70u W=94.8u       ; M device
R203m 1 0 6.8M                           ; R device
C203n 2 1 99n                            ; C device
M203o 3 2 0 1 NMOS L=0.13u W=36.5u       ; M device
M203p 3 0 2 1 NMOS L=0.25u W=85.5u
+ AD=84.82p AS=28.94p PD=198.9u PS=317.3u ; M device
M203q 0 1 2 3 PMOS L=0.13u W=44.6u       ; M device
R203r 0 2 54k                            ; R device
M203s 0 3 1 2 PMOS L=0.35u W=97.9u       ; M device
C203t 2 3 3.6m                           ; C device
R203u 1 3 44k                            ; R device
R203v 3 0 692                            ; R device
C203w 3 0 2.5u                           ; C device
C203x 1 2 0.7m                           ; C device
C203y 0 3 52n                            ; C device
R203z 2 0 0.7M                           ; R device
R204a 0 1 6.5M                           ; R device
C204b 3 1 456p                           ; C device
M204c 2 1 3 0 NMOS L=0.13u W=71.6u       ; M device
C204d 3 2 3.6m                           ; C device
R204e 3 0 4.8M                           ; R device
M204f 0 2 1 3 PMOS L=0.25u W=97.2u
+ AD=29.05p AS=114.20p PD=358.6u PS=381.8u ; M device
M204g 3 2 0 1 PMOS L=0.70u W=56.3u       ; M device
C204h 2 0 7.7m                           ; C device
R204i 2 0 589                            ; R device
M204j 3 2 0 1 PMOS L=0.25u W=67.4u AD=33.29p AS=56.22p PD=215.2u PS=256.2u ; M device
R204k 0 3 6.8M                           ; R device
M204l 3 2 0 1 NMOS L=0.35u W=64.0u
+ AD=89.03p AS=104.72p PD=177.2u PS=194.4u ; M device
R204m 3 2 49k                            ; R device
C204n 3 2 7.6u                           ; C device
M204o 2 1 0 3 PMOS L=0.35u W=94.6u
+ AD=174.97p AS=92.55p PD=207.5u PS=215.9u ; M device
M204p 0 1 3 2 NMOS L=0.25u W=67.2u       ; M device
R204q 3 2 1.9M                           ; R device
R204r 3 0 1.9M                           ; R device
R204s 3 1 89                             ; R device
C204t 3 2 1n                             ; C device
M204u 2 3 1 0 NMOS L=0.35u W=80.9u AD=100.94p AS=51.92p PD=187.9u PS=193.8u ; M device
R204v 0 1 9.0M                           ; R device
M204w 2 1 3 0 PMOS L=1.00u W=19.8u       ; M device
R204x 1 0 93k                            ; R device
M204y 1 3 0 2 NMOS L=0.35u W=7.7u        ; M device
C204z 1 2 7.5m                           ; C device
C205a 1 3 9.7u                           ; C device
M205b 3 0 1 2 NMOS L=0.18u W=84.6u AD=147.61p AS=50.73p PD=335.9u PS=310.0u ; M device
C205c 3 0 0.8u                           ; C device
C205d 0 1 46n                            ; C device
R205e 2 3 915                            ; R device
M205f 1 0 2 3 PMOS L=0.50u W=98.0u       ; M device
C205g 0 1 1.1m                           ; C device
C205h 3 2 0.1u                           ; C device
C205i 3 2 9.1m                           ; C device
M205j 1 0 2 3 PMOS L=0.10u W=5.9u
+ AD=8.59p AS=3.66p PD=13.2u PS=14.7u ; M device
R205k 1 3 9.4M                           ; R device
M205l 3 2 0 1 PMOS L=0.13u W=3.0u        ; M device
M205m 2 0 1 3 NMOS L=0.35u W=75.3u
+ AD=69.65p AS=127.79p PD=269.9u PS=211.4u ; M device
R205n 2 3 0.5M                           ; R device
C205o 3 2 8.7u                           ; C device
M205p 3 1 0 2 PMOS L=0.13u W=41.4u       ; M device
M205q 2 3 1 0 NMOS L=0.70u W=15.7u       ; M device
R205r 2 0 9.9M                           ; R device
R205s 1 0 306                            ; R device
C205t 0 1 7.0m                           ; C device
M205u 3 2 0 1 PMOS L=0.13u W=88.8u AD=30.89p AS=11.60p PD=296.2u PS=248.1u ; M device
M205v 3 1 0 2 NMOS L=0.25u W=90.6u
+ AD=85.74p AS=84.66p PD=242.9u PS=272.7u ; M device
M205w 2 3 0 1 PMOS L=0.50u W=50.3u
+ AD=14.22p AS=61.41p PD=135.7u PS=136.4u ; M device
R205x 3 0 16k                            ; R device
R205y 1 3 3.4M                           ; R device
C205z 2 1 22n                            ; C device
M206a 2 0 3 1 NMOS L=0.50u W=87.5u AD=54.88p AS=164.22p PD=264.9u PS=247.3u ; M device
R206b 3 1 173                            ; R device
R206c 1 3 2.0M                           ; R device
C206d 1 0 14n                            ; C device
R206e 3 0 881                            ; R device
M206f 0 1 2 3 PMOS L=0.70u W=86.0u AD=66.63p AS=53.67p PD=275.8u PS=186.3u ; M device
R206g 3 2 875                            ; R device
C206h 3 0 651p                           ; C device
R206i 3 0 933                            ; R device
M206j 1 3 2 0 PMOS L=0.13u W=91.4u AD=54.08p AS=21.40p PD=253.8u PS=299.1u ; M device
R206k 3 2 135                            ; R device
C206l 2 0 8.1m                           ; C device
C206m 3 1 89n                            ; C device
M206n 3 0 2 1 NMOS L=0.70u W=72.4u       ; M device
M206o 1 2 3 0 NMOS L=1.00u W=68.9u
+ AD=67.20p AS=122.87p PD=195.3u PS=209.4u ; M device
M206p 1 2 0 3 NMOS L=1.00u W=48.8u       ; M device
R206q 0 1 298                            ; R device
M206r 3 0 1 2 NMOS L=0.25u W=30.7u
+ AD=18.41p AS=56.17p PD=77.7u PS=113.4u ; M device
M206s 1 3 0 2 NMOS L=0.13u W=71.5u
+ AD=98.15p AS=35.97p PD=181.2u PS=167.6u ; M device
C206t 3 2 9.7u                           ; C device
C206u 1 3 5.4m                           ; C device
C206v 1 0 2.2u                           ; C device
C206w 3 2 7.1m                           ; C device
M206x 2 0 3 1 NMOS L=0.18u W=19.8u       ; M device
M206y 3 1 0 2 NMOS L=0.70u W=51.2u AD=47.50p AS=57.96p PD=132.5u PS=193.3u ; M device
M206z 3 0 1 2 NMOS L=0.10u W=48.4u
+ AD=52.15p AS=44.51p PD=192.1u PS=186.3u ; M device
M207a 2 1 0 3 PMOS L=0.10u W=80.0u AD=28.26p AS=125.91p PD=268.7u PS=222.3u ; M device
M207b 3 1 0 2 NMOS L=0.70u W=99.9u       ; M device
C207c 3 0 7.8u                           ; C device
M207d 2 0 1 3 NMOS L=0.70u W=90.1u       ; M device
C207e 1 3 773p                           ; C device
C207f 1 0 2.6m                           ; C device
C207g 0 1 838p                           ; C device
M207h 3 0 2 1 NMOS L=0.70u W=79.4u AD=22.90p AS=40.25p PD=225.1u PS=242.1u ; M device
C207i 3 0 969p                           ; C device
M207j 1 3 0 2 PMOS L=0.35u W=77.4u       ; M device
R207k 1 3 7.1M                           ; R device
C207l 0 3 49n                            ; C device
M207m 1 2 3 0 PMOS L=0.70u W=41.0u AD=38.57p AS=7.68p PD=146.3u PS=138.4u ; M device
C207n 3 1 5.4u                           ; C device
M207o 2 1 0 3 PMOS L=0.13u W=61.0u
+ AD=29.72p AS=72.05p PD=191.5u PS=148.2u ; M device
R207p 0 2 1.7M                           ; R device
R207q 0 2 63k                            ; R device
R207r 1 0 5.5M                           ; R device
R207s 3 2 761                            ; R device
C207t 1 3 7.0m                           ; C device
R207u 0 3 2.3M                           ; R device
C207v 0 1 754p                           ; C device
M207w 3 1 0 2 PMOS L=0.35u W=62.1u AD=103.73p AS=7.26p PD=218.4u PS=223.0u ; M device
R207x 3 1 72                             ; R device
M207y 0 1 2 3 NMOS L=1.00u W=70.5u       ; M device
C207z 3 1 964p                           ; C device
M208a 1 2 0 3 NMOS L=0.35u W=66.4u       ; M device
M208b 1 2 3 0 NMOS L=1.00u W=31.3u       ; M device
C208c 2 3 20n                            ; C device
M208d 3 1 2 0 PMOS L=0.35u W=53.6u AD=50.81p AS=36.99p PD=164.6u PS=184.8u ; M device
R208e 1 0 7.8M                           ; R device
M208f 0 3 2 1 PMOS L=0.13u W=12.2u
+ AD=24.21p AS=8.54p PD=47.3u PS=26.6u ; M device
M208g 0 2 3 1 PMOS L=0.35u W=21.9u       ; M device
M208h 1 3 2 0 NMOS L=0.35u W=28.3u
+ AD=35.56p AS=26.78p PD=59.4u PS=80.1u ; M device
R208i 1 0 276                            ; R device
R208j 1 0 178                            ; R device
M208k 3 1 0 2 NMOS L=0.13u W=11.9u AD=21.95p AS=14.28p PD=43.7u PS=27.7u ; M device
M208l 1 2 0 3 NMOS L=0.18u W=70.7u
+ AD=94.56p AS=136.93p PD=253.8u PS=167.9u ; M device
R208m 2 3 3.8M                           ; R device
C208n 1 0 7.7u                           ; C device
C208o 0 2 67n                            ; C device
R208p 3 2 39k                            ; R device
M208q 2 1 0 3 NMOS L=1.00u W=22.6u       ; M device
C208r 1 3 83p                            ; C device
M208s 1 3 2 0 PMOS L=0.18u W=75.0u
+ AD=8.86p AS=143.77p PD=226.6u PS=261.4u ; M device
M208t 1 2 0 3 PMOS L=0.13u W=63.2u       ; M device
C208u 1 0 62n                            ; C device
R208v 2 1 78k                            ; R device
R208w 3 0 365                            ; R device
C208x 0 1 54p                            ; C device
R208y 3 0 773                            ; R device
C208z 1 3 1.0m                           ; C device
C209a 2 0 13n                            ; C device
R209b 3 2 8.9M                           ; R device
M209c 2 1 3 0 NMOS L=0.18u W=12.3u AD=17.17p AS=11.80p PD=25.9u PS=28.6u ; M device
R209d 1 0 5.0M                           ; R device
C209e 2 3 922p                           ; C device
M209f 3 1 0 2 PMOS L=0.10u W=33.1u       ; M device
M209g 2 3 1 0 PMOS L=0.25u W=59.4u       ; M device
R209h 3 0 68k                            ; R device
C209i 3 1 2.3u                           ; C device
M209j 1 3 2 0 PMOS L=0.25u W=92.8u AD=86.42p AS=115.90p PD=261.3u PS=350.2u ; M device
C209k 1 3 8.1u                           ; C device
M209l 2 1 0 3 NMOS L=0.50u W=49.7u AD=57.89p AS=24.87p PD=118.3u PS=105.9u ; M device
M209m 2 0 3 1 PMOS L=0.50u W=52.3u
+ AD=100.68p AS=59.78p PD=202.3u PS=109.3u ; M device
C209n 0 3 5.5m                           ; C device
R209o 1 3 7.2M                           ; R device
C209p 3 2 0.7u                           ; C device
C209q 0 3 257p                           ; C device
M209r 2 1 0 3 PMOS L=0.70u W=91.0u AD=88.73p AS=51.61p PD=299.9u PS=309.8u ; M device
R209s 1 2 974                            ; R device
R209t 1 0 0.4M                           ; R device
M209u 1 2 0 3 NMOS L=0.10u W=51.3u       ; M device
M209v 1 2 0 3 PMOS L=0.13u W=46.5u       ; M device
C209w 2 1 258p                           ; C device
R209x 0 3 450                            ; R device
M209y 3 0 2 1 NMOS L=0.35u W=46.2u       ; M device
C209z 0 1 0.4m                           ; C device
C210a 0 3 188p                           ; C device
M210b 3 2 1 0 NMOS L=0.25u W=91.9u
+ AD=164.15p AS=152.50p PD=273.5u PS=235.1u ; M device
C210c 0 2 92p                            ; C device
C210d 1 0 41n                            ; C device
C210e 0 1 1.3u                           ; C device
R210f 3 1 2.6M                           ; R device
M210g 3 0 1 2 PMOS L=0.18u W=88.2u       ; M device
C210h 1 2 38n                            ; C device
C210i 0 1 92n                            ; C device
R210j 3 0 98k                            ; R device
C210k 0 3 14n                            ; C device
R210l 2 0 43k                            ; R device
R210m 3 0 95k                            ; R device
R210n 0 3 66k                            ; R device
C210o 2 3 9.4m                           ; C device
R210p 2 1 3.2M                           ; R device
C210q 0 3 4.3u                           ; C device
C210r 1 2 3n                             ; C device
R210s 3 0 9.0M                           ; R device
M210t 3 2 0 1 NMOS L=0.35u W=75.4u
+ AD=109.42p AS=137.99p PD=254.3u PS=225.5u ; M device
M210u 3 1 0 2 PMOS L=0.18u W=10.1u       ; M device
M210v 3 2 1 0 NMOS L=0.70u W=0.6u AD=1.01p AS=0.22p PD=1.2u PS=1.6u ; M device
R210w 3 2 7.5M                           ; R device
M210x 2 1 3 0 NMOS L=0.13u W=71.5u AD=90.79p AS=110.72p PD=152.0u PS=203.0u ; M device
C210y 0 2 32n                            ; C device
C210z 3 2 6.4m                           ; C device
C211a 2 1 7.4m                           ; C device
C211b 1 3 697p                           ; C device
M211c 3 0 1 2 PMOS L=0.25u W=19.4u AD=18.72p AS=33.65p PD=59.4u PS=47.4u ; M device
C211d 3 1 2.5m                           ; C device
R211e 2 3 69k                            ; R device
C211f 3 0 34n                            ; C device
C211g 0 3 41p                            ; C device
R211h 3 0 7.3M                           ; R device
C211i 1 0 737p                           ; C device
M211j 2 1 3 0 PMOS L=0.10u W=13.7u       ; M device
C211k 0 1 7.2m                           ; C device
C211l 1 0 458p                           ; C device
C211m 0 2 6.5u                           ; C device
C211n 3 0 58n                            ; C device
C211o 2 0 0.3m                           ; C device
R211p 2 1 7.7M                           ; R device
C211q 0 3 7.4u                           ; C device
M211r 1 2 0 3 NMOS L=1.00u W=13.5u       ; M device
M211s 1 0 2 3 PMOS L=0.18u W=70.7u
+ AD=133.85p AS=23.25p PD=157.2u PS=194.0u ; M device
R211t 0 3 613                            ; R device
C211u 2 1 59n                            ; C device
R211v 1 0 1.5M                           ; R device
M211w 1 0 3 2 PMOS L=0.10u W=48.8u AD=66.20p AS=79.20p PD=181.9u PS=167.4u ; M device
M211x 3 2 1 0 PMOS L=1.00u W=78.4u       ; M device
C211y 3 1 46n                            ; C device
C211z 2 0 9.6m                           ; C device
M212a 2 1 3 0 NMOS L=0.50u W=34.3u       ; M device
C212b 3 2 6.4m                           ; C device
M212c 3 0 1 2 NMOS L=1.00u W=96.5u AD=169.57p AS=46.77p PD=288.8u PS=225.7u ; M device
C212d 2 1 755p                           ; C device
R212e 1 2 2k                             ; R device
M212f 1 0 3 2 PMOS L=0.50u W=16.4u
+ AD=13.09p AS=31.33p PD=65.4u PS=45.0u ; M device
R212g 1 0 97                             ; R device
C212h 2 0 7n                             ; C device
R212i 0 1 65k                            ; R device
M212j 3 2 1 0 NMOS L=0.70u W=13.9u
+ AD=13.62p AS=12.33p PD=33.5u PS=37.6u ; M device
R212k 0 3 90k                            ; R device
M212l 0 2 1 3 PMOS L=0.18u W=52.5u
+ AD=10.89p AS=76.17p PD=182.4u PS=158.3u ; M device
R212m 2 3 860                            ; R device
C212n 1 2 673p                           ; C device
M212o 3 2 0 1 PMOS L=0.50u W=31.5u AD=28.25p AS=44.11p PD=76.0u PS=66.3u ; M device
M212p 2 3 1 0 NMOS L=0.50u W=52.1u
+ AD=46.19p AS=58.23p PD=150.3u PS=182.7u ; M device
C212q 1 0 84n                            ; C device
C212r 1 2 916p                           ; C device
C212s 0 2 92n                            ; C device
R212t 1 3 1.6M                           ; R device
R212u 3 0 622                            ; R device
R212v 2 0 731                            ; R device
C212w 3 0 85n                            ; C device
M212x 2 3 0 1 NMOS L=0.18u W=80.4u       ; M device
C212y 1 0 62n                            ; C device
M212z 3 0 1 2 PMOS L=0.13u W=68.1u
+ AD=106.94p AS=17.01p PD=230.9u PS=143.8u ; M device
R213a 2 1 85k                            ; R device
C213b 0 2 4.8m                           ; C device
M213c 0 3 1 2 PMOS L=0.35u W=69.9u       ; M device
C213d 2 1 5.1m                           ; C device
C213e 1 3 9.1u                           ; C device
R213f 1 2 9.5M                           ; R device
M213g 2 3 1 0 NMOS L=0.70u W=68.6u
+ AD=10.05p AS=80.63p PD=151.6u PS=188.9u ; M device
R213h 3 2 6.8M                           ; R device
M213i 1 3 2 0 PMOS L=0.13u W=85.9u       ; M device
R213j 1 2 2.0M                           ; R device
C213k 0 2 10.0u                          ; C device
C213l 0 1 5.8m                           ; C device
M213m 1 0 3 2 NMOS L=1.00u W=50.1u AD=26.54p AS=65.55p PD=100.4u PS=158.3u ; M device
M213n 3 2 0 1 PMOS L=0.18u W=16.2u       ; M device
R213o 3 0 625                            ; R device
M213p 0 2 1 3 PMOS L=0.13u W=43.4u AD=85.20p AS=52.04p PD=99.0u PS=126.6u ; M device
R213q 2 1 1.4M                           ; R device
R213r 3 1 111                            ; R device
R213s 3 1 36k                            ; R device
C213t 1 2 4.9u                           ; C device
R213u 3 1 55k                            ; R device
C213v 3 2 45n                            ; C device
R213w 0 2 3.2M                           ; R device
R213x 3 0 827                            ; R device
R213y 2 3 18k                            ; R device
R213z 0 1 2.1M                           ; R device
C214a 1 0 885p                           ; C device
R214b 3 0 28k                            ; R device
R214c 0 2 55k                            ; R device
C214d 3 1 768p                           ; C device
C214e 3 2 21n                            ; C device
C214f 2 3 1.8u                           ; C device
C214g 3 0 9.8m                           ; C device
C214h 2 3 83n                            ; C device
C214i 3 2 4.1u                           ; C device
R214j 2 3 347                            ; R device
R214k 2 0 2.9M                           ; R device
R214l 3 1 86k                            ; R device
C214m 0 3 188p                           ; C device
C214n 0 1 85n                            ; C device
R214o 3 0 625                            ; R device
R214p 0 1 9.4M                           ; R device
C214q 2 0 5.9m                           ; C device
C214r 0 3 88n                            ; C device
M214s 3 1 2 0 PMOS L=0.70u W=24.2u       ; M device
R214t 2 0 42k                            ; R device
C214u 1 3 653p                           ; C device
M214v 0 3 2 1 NMOS L=1.00u W=25.3u AD=42.06p AS=14.97p PD=78.8u PS=64.0u ; M device
M214w 1 3 2 0 NMOS L=0.35u W=34.4u AD=30.21p AS=58.75p PD=127.9u PS=95.1u ; M device
M214x 0 1 2 3 NMOS L=0.13u W=5.9u
+ AD=4.85p AS=11.53p PD=15.5u PS=23.6u ; M device
R214y 0 1 3.7M                           ; R device
C214z 1 3 5.0m                           ; C device
M215a 1 2 3 0 NMOS L=0.50u W=20.0u
+ AD=36.45p AS=13.31p PD=79.9u PS=72.1u ; M device
R215b 1 0 6.1M                           ; R device
R215c 0 1 3.5M                           ; R device
M215d 3 2 1 0 NMOS L=1.00u W=6.3u        ; M device
M215e 0 1 3 2 NMOS L=0.70u W=10.0u
+ AD=16.92p AS=11.78p PD=30.0u PS=23.9u ; M device
R215f 2 0 21k                            ; R device
C215g 1 3 51p                            ; C device
R215h 2 1 5.7M                           ; R device
M215i 2 0 1 3 NMOS L=1.00u W=25.9u       ; M device
C215j 0 3 23n                            ; C device
R215k 2 0 610                            ; R device
R215l 1 3 9.9M                           ; R device
M215m 0 2 1 3 PMOS L=0.10u W=4.6u        ; M device
C215n 2 1 9.0u                           ; C device
M215o 2 1 0 3 NMOS L=0.70u W=64.8u       ; M device
M215p 3 0 2 1 NMOS L=1.00u W=48.3u       ; M device
M215q 3 1 0 2 PMOS L=0.10u W=71.8u       ; M device
R215r 1 0 30k                            ; R device
C215s 3 0 72n                            ; C device
M215t 2 0 1 3 NMOS L=0.10u W=24.1u
+ AD=41.62p AS=14.54p PD=65.7u PS=93.9u ; M device
M215u 0 2 1 3 PMOS L=0.10u W=32.9u       ; M device
M215v 2 1 3 0 PMOS L=1.00u W=99.8u
+ AD=180.58p AS=179.25p PD=236.7u PS=225.9u ; M device
M215w 2 0 3 1 NMOS L=0.35u W=96.8u AD=74.32p AS=96.37p PD=290.1u PS=196.2u ; M device
M215x 1 3 0 2 PMOS L=0.13u W=61.7u
+ AD=116.97p AS=62.84p PD=205.5u PS=194.0u ; M device
C215y 1 0 10.0m                          ; C device
C215z 3 0 3.4u                           ; C device
C216a 3 1 5.5u                           ; C device
R216b 1 2 89k                            ; R device
R216c 0 2 57                             ; R device
C216d 3 2 14n                            ; C device
R216e 0 2 43k                            ; R device
R216f 3 0 8.0M                           ; R device
R216g 1 3 445                            ; R device
C216h 2 1 6.5m                           ; C device
R216i 2 3 63k                            ; R device
R216j 1 2 56                             ; R device
C216k 2 1 2.2m                           ; C device
C216l 1 0 8n                             ; C device
M216m 3 2 0 1 NMOS L=0.10u W=11.8u       ; M device
C216n 1 0 4.4m                           ; C device
C216o 3 2 3n                             ; C device
R216p 0 1 6.9M                           ; R device
M216q 2 1 0 3 NMOS L=0.13u W=13.2u
+ AD=2.71p AS=23.77p PD=40.4u PS=50.4u ; M device
M216r 1 2 0 3 PMOS L=0.10u W=27.2u
+ AD=21.41p AS=9.71p PD=102.1u PS=67.2u ; M device
C216s 1 0 1.7u                           ; C device
R216t 0 3 9.8M                           ; R device
C216u 2 1 508p                           ; C device
M216v 0 2 1 3 NMOS L=0.70u W=85.7u       ; M device
R216w 0 2 67k                            ; R device
C216x 0 2 177p                           ; C device
C216y 2 1 3.1m                           ; C device
R216z 1 3 78k                            ; R device
M217a 1 2 0 3 PMOS L=0.35u W=64.9u       ; M device
M217b 3 0 1 2 NMOS L=0.35u W=63.0u       ; M device
C217c 2 0 0.6m                           ; C device
R217d 1 2 3.7M                           ; R device
R217e 1 0 837                            ; R device
M217f 3 2 0 1 NMOS L=0.50u W=68.4u       ; M device
C217g 3 2 2.4m                           ; C device
R217h 0 2 4.0M                           ; R device
M217i 2 1 0 3 PMOS L=0.25u W=42.1u       ; M device
C217j 2 3 0.8m                           ; C device
R217k 1 0 463                            ; R device
C217l 2 0 70n                            ; C device
R217m 2 1 89k                            ; R device
M217n 0 1 3 2 NMOS L=0.25u W=22.7u       ; M device
R217o 2 1 7.7M                           ; R device
R217p 2 3 8k                             ; R device
R217q 2 3 517                            ; R device
R217r 3 0 65k                            ; R device
M217s 1 2 3 0 PMOS L=0.13u W=93.7u AD=131.03p AS=117.28p PD=247.8u PS=239.0u ; M device
R217t 1 0 3.1M                           ; R device
M217u 2 1 3 0 PMOS L=0.70u W=72.1u       ; M device
M217v 2 0 3 1 PMOS L=0.13u W=77.9u       ; M device
R217w 0 2 18k                            ; R device
M217x 3 2 0 1 NMOS L=0.10u W=95.2u       ; M device
R217y 1 3 207                            ; R device
R217z 3 2 8k                             ; R device
M218a 3 2 0 1 PMOS L=0.25u W=7.9u        ; M device
C218b 0 1 28n                            ; C device
R218c 2 3 5.8M                           ; R device
C218d 1 2 9.8u                           ; C device
R218e 2 1 226                            ; R device
C218f 0 2 244p                           ; C device
C218g 0 1 59n                            ; C device
M218h 3 2 1 0 NMOS L=0.10u W=81.0u       ; M device
C218i 2 0 1.9m                           ; C device
C218j 1 3 317p                           ; C device
R218k 0 3 26k                            ; R device
C218l 3 1 43n                            ; C device
C218m 0 1 748p                           ; C device
C218n 3 0 4.6m                           ; C device
M218o 3 1 0 2 NMOS L=0.10u W=13.8u       ; M device
M218p 0 2 3 1 NMOS L=0.25u W=80.5u       ; M device
R218q 1 0 482                            ; R device
R218r 2 3 25k                            ; R device
M218s 2 0 3 1 PMOS L=0.18u W=44.7u AD=6.04p AS=22.94p PD=141.7u PS=104.4u ; M device
C218t 1 0 9.5m                           ; C device
C218u 2 3 20n                            ; C device
C218v 0 3 1.6u                           ; C device
M218w 2 3 1 0 NMOS L=1.00u W=15.3u
+ AD=6.94p AS=26.96p PD=45.6u PS=57.6u ; M device
C218x 0 1 6.9u                           ; C device
C218y 0 1 538p                           ; C device
R218z 3 2 977                            ; R device
C219a 1 0 3.2m                           ; C device
M219b 0 2 1 3 NMOS L=0.70u W=7.9u        ; M device
R219c 2 3 42k                            ; R device
M219d 2 3 1 0 PMOS L=0.13u W=26.1u AD=43.02p AS=9.27p PD=56.8u PS=103.0u ; M device
R219e 0 2 73k                            ; R device
R219f 1 3 4.4M                           ; R device
R219g 2 3 2.9M                           ; R device
M219h 2 1 3 0 PMOS L=0.25u W=54.7u AD=5.89p AS=15.45p PD=173.3u PS=172.5u ; M device
R219i 3 1 7.8M                           ; R device
R219j 0 3 656                            ; R device
R219k 2 0 17k                            ; R device
R219l 1 2 64k                            ; R device
R219m 0 2 875                            ; R device
C219n 1 3 197p                           ; C device
R219o 0 3 97k                            ; R device
M219p 3 1 2 0 PMOS L=0.35u W=55.4u       ; M device
M219q 0 2 1 3 PMOS L=0.25u W=10.7u
+ AD=16.96p AS=11.05p PD=41.9u PS=24.1u ; M device
R219r 3 2 71k                            ; R device
M219s 0 2 1 3 PMOS L=0.50u W=36.5u       ; M device
M219t 0 1 2 3 PMOS L=0.25u W=2.8u
+ AD=2.75p AS=3.92p PD=7.6u PS=8.0u ; M device
M219u 0 1 3 2 PMOS L=1.00u W=98.3u AD=132.57p AS=172.42p PD=306.8u PS=257.0u ; M device
R219v 1 3 23k                            ; R device
R219w 1 3 92k                            ; R device
R219x 0 2 8.5M                           ; R device
C219y 2 0 59n                            ; C device
R219z 2 3 0.2M                           ; R device
R220a 1 3 86k                            ; R device
R220b 0 2 74                             ; R device
M220c 2 0 1 3 NMOS L=0.35u W=89.1u       ; M device
C220d 0 1 2.5m                           ; C device
R220e 1 2 9.5M                           ; R device
R220f 3 0 97k                            ; R device
R220g 3 0 169                            ; R device
R220h 3 0 3.7M                           ; R device
C220i 3 1 99n                            ; C device
R220j 3 1 79k                            ; R device
C220k 3 1 8.6u                           ; C device
C220l 3 0 1.6u                           ; C device
C220m 3 2 9.5u                           ; C device
R220n 2 1 488                            ; R device
M220o 2 1 3 0 PMOS L=0.13u W=90.7u       ; M device
C220p 0 3 83p                            ; C device
C220q 1 3 4.8m                           ; C device
R220r 1 0 146                            ; R device
R220s 0 1 15k                            ; R device
C220t 0 1 6n                             ; C device
M220u 1 2 3 0 NMOS L=0.35u W=75.9u
+ AD=87.17p AS=118.23p PD=186.1u PS=168.8u ; M device
C220v 1 3 709p                           ; C device
R220w 2 0 1.8M                           ; R device
C220x 3 2 5.5m                           ; C device
C220y 3 2 420p                           ; C device
M220z 3 1 2 0 NMOS L=0.50u W=25.7u       ; M device
C221a 0 2 80n                            ; C device
M221b 0 3 2 1 PMOS L=0.50u W=41.8u AD=62.97p AS=82.40p PD=86.1u PS=151.8u ; M device
C221c 0 3 49n                            ; C device
R221d 2 3 8.9M                           ; R device
C221e 0 1 6.3m                           ; C device
R221f 1 2 79k                            ; R device
C221g 1 2 191p                           ; C device
R221h 1 0 663                            ; R device
R221i 3 2 93k                            ; R device
C221j 2 0 0.9m                           ; C device
R221k 0 2 71k                            ; R device
R221l 2 0 430                            ; R device
M221m 0 1 3 2 NMOS L=0.70u W=84.0u       ; M device
M221n 2 1 0 3 PMOS L=0.25u W=87.1u       ; M device
R221o 1 0 273                            ; R device
M221p 0 2 3 1 NMOS L=0.35u W=8.9u        ; M device
R221q 0 3 1.5M                           ; R device
C221r 1 3 6.4u                           ; C device
C221s 2 0 1.3m                           ; C device
C221t 2 3 80n                            ; C device
M221u 0 3 1 2 PMOS L=0.10u W=98.6u AD=129.73p AS=110.05p PD=255.9u PS=275.9u ; M device
C221v 1 3 4.7u                           ; C device
C221w 3 2 642p                           ; C device
R221x 2 3 5.7M                           ; R device
M221y 3 1 0 2 PMOS L=0.50u W=71.7u       ; M device
C221z 2 1 1.9m                           ; C device
R222a 0 1 45k                            ; R device
C222b 3 0 88n                            ; C device
R222c 1 0 1.0M                           ; R device
R222d 3 2 19k                            ; R device
M222e 2 0 1 3 PMOS L=0.35u W=46.8u AD=82.07p AS=90.12p PD=94.7u PS=182.9u ; M device
C222f 3 1 3.0m                           ; C device
R222g 2 0 3.8M                           ; R device
C222h 3 1 5.1u                           ; C device
C222i 1 2 3.2m                           ; C device
R222j 3 0 36k                            ; R device
C222k 2 3 285p                           ; C device
R222l 0 3 50k                            ; R device
C222m 0 3 3.9m                           ; C device
R222n 2 0 127                            ; R device
R222o 2 0 27k                            ; R device
R222p 3 1 74k                            ; R device
R222q 2 1 65k                            ; R device
R222r 3 2 4.3M                           ; R device
R222s 0 2 192                            ; R device
C222t 0 1 472p                           ; C device
C222u 3 0 7.3m                           ; C device
M222v 0 1 2 3 NMOS L=0.10u W=97.8u       ; M device
C222w 0 3 6.6m                           ; C device
R222x 3 0 63k                            ; R device
R222y 1 2 35k                            ; R device
R222z 2 1 45k                            ; R device
R223a 2 3 67k                            ; R device
R223b 1 0 9.7M                           ; R device
C223c 0 2 10.0m                          ; C device
C223d 2 1 34n                            ; C device
M223e 0 1 2 3 PMOS L=0.35u W=66.9u       ; M device
C223f 0 1 860p                           ; C device
R223g 1 2 61                             ; R device
M223h 0 1 2 3 PMOS L=1.00u W=21.3u
+ AD=8.56p AS=22.39p PD=57.5u PS=44.4u ; M device
C223i 0 1 9.9u                           ; C device
M223j 3 1 2 0 NMOS L=0.13u W=93.0u       ; M device
C223k 3 0 427p                           ; C device
R223l 1 3 426                            ; R device
C223m 2 1 5.7u                           ; C device
M223n 3 0 2 1 PMOS L=0.70u W=90.2u       ; M device
R223o 2 1 8.6M                           ; R device
C223p 3 0 255p                           ; C device
R223q 0 2 634                            ; R device
C223r 0 2 4.2m                           ; C device
C223s 0 3 7.6u                           ; C device
C223t 1 2 4.0u                           ; C device
R223u 2 0 806                            ; R device
M223v 1 2 0 3 NMOS L=0.18u W=68.0u       ; M device
C223w 1 0 3.3u                           ; C device
C223x 3 2 1.3u                           ; C device
M223y 1 3 2 0 PMOS L=0.35u W=59.5u       ; M device
C223z 2 3 668p                           ; C device
C224a 2 1 4.8m                           ; C device
R224b 0 1 4.1M                           ; R device
M224c 1 0 3 2 NMOS L=0.18u W=1.1u AD=1.27p AS=1.20p PD=2.2u PS=3.5u ; M device
C224d 1 2 4.2u                           ; C device
M224e 3 1 0 2 PMOS L=0.10u W=38.1u       ; M device
R224f 2 1 25k                            ; R device
R224g 2 0 6.8M                           ; R device
C224h 2 1 2.1u                           ; C device
R224i 0 3 50k                            ; R device
R224j 3 2 7.7M                           ; R device
C224k 1 0 5.2u                           ; C device
M224l 1 0 2 3 PMOS L=0.25u W=9.9u        ; M device
C224m 3 2 46n                            ; C device
R224n 1 0 478                            ; R device
C224o 3 1 0.7u                           ; C device
C224p 3 1 121p                           ; C device
M224q 1 3 2 0 NMOS L=0.35u W=74.0u       ; M device
M224r 0 2 1 3 NMOS L=0.18u W=5.9u
+ AD=10.75p AS=7.59p PD=18.1u PS=12.9u ; M device
C224s 1 3 999p                           ; C device
M224t 2 1 0 3 NMOS L=0.70u W=48.6u AD=89.37p AS=65.12p PD=120.0u PS=173.9u ; M device
M224u 2 0 3 1 PMOS L=0.50u W=43.4u       ; M device
C224v 0 2 6.3m                           ; C device
R224w 2 3 975                            ; R device
R224x 1 2 1.7M                           ; R device
C224y 0 3 0.4m                           ; C device
M224z 2 1 3 0 PMOS L=0.50u W=8.9u AD=16.21p AS=10.76p PD=34.8u PS=27.6u ; M device
M225a 0 1 2 3 PMOS L=1.00u W=37.8u       ; M device
C225b 3 1 11p                            ; C device
M225c 3 0 1 2 NMOS L=0.18u W=5.6u        ; M device
M225d 0 3 1 2 NMOS L=0.13u W=49.5u       ; M device
R225e 1 0 330                            ; R device
R225f 1 2 73k                            ; R device
M225g 2 0 1 3 NMOS L=0.35u W=80.1u AD=16.16p AS=10.63p PD=186.9u PS=183.3u ; M device
C225h 3 0 17n                            ; C device
C225i 0 2 6.1m                           ; C device
R225j 1 3 67k                            ; R device
C225k 0 3 121p                           ; C device
C225l 1 0 213p                           ; C device
R225m 1 3 309                            ; R device
R225n 1 0 5.8M                           ; R device
C225o 3 2 6n                             ; C device
M225p 1 2 3 0 NMOS L=0.25u W=99.7u       ; M device
C225q 0 3 487p                           ; C device
R225r 1 0 41k                            ; R device
C225s 1 2 1.2m                           ; C device
M225t 0 3 2 1 PMOS L=0.10u W=39.3u       ; M device
C225u 3 1 63p                            ; C device
R225v 2 1 37k                            ; R device
M225w 2 1 3 0 PMOS L=0.70u W=86.6u
+ AD=89.77p AS=106.29p PD=199.1u PS=311.1u ; M device
R225x 1 3 5.2M                           ; R device
R225y 0 2 0.5M                           ; R device
M225z 1 3 2 0 PMOS L=0.10u W=87.6u       ; M device
R226a 1 0 65k                            ; R device
M226b 1 3 0 2 NMOS L=0.50u W=96.3u
+ AD=174.01p AS=67.49p PD=317.0u PS=284.3u ; M device
M226c 2 3 0 1 PMOS L=0.10u W=4.4u        ; M device
R226d 0 1 785                            ; R device
M226e 1 2 0 3 NMOS L=0.18u W=16.2u
+ AD=30.30p AS=21.86p PD=38.8u PS=34.1u ; M device
M226f 0 2 1 3 NMOS L=0.50u W=11.7u       ; M device
C226g 3 1 19n                            ; C device
R226h 2 3 10k                            ; R device
C226i 3 0 192p                           ; C device
R226j 0 3 223                            ; R device
C226k 0 1 3.1m                           ; C device
R226l 1 2 40k                            ; R device
R226m 3 0 920                            ; R device
C226n 1 0 0.1m                           ; C device
M226o 1 0 3 2 NMOS L=0.13u W=9.1u
+ AD=17.19p AS=3.15p PD=22.8u PS=35.3u ; M device
C226p 3 2 77n                            ; C device
R226q 1 3 70k                            ; R device
C226r 0 3 4.0m                           ; C device
M226s 2 1 3 0 NMOS L=0.25u W=30.9u       ; M device
M226t 0 2 1 3 NMOS L=0.18u W=52.7u       ; M device
M226u 0 1 3 2 PMOS L=0.35u W=61.1u       ; M device
R226v 0 3 3.3M                           ; R device
R226w 1 2 641                            ; R device
R226x 1 3 6.6M                           ; R device
R226y 3 1 5.4M                           ; R device
R226z 2 3 70k                            ; R device
M227a 2 3 0 1 PMOS L=0.35u W=71.3u       ; M device
M227b 1 3 0 2 PMOS L=1.00u W=42.5u       ; M device
R227c 1 0 79k                            ; R device
R227d 3 2 7.9M                           ; R device
R227e 3 2 8.8M                           ; R device
R227f 3 0 7.2M                           ; R device
M227g 0 2 3 1 NMOS L=0.50u W=71.7u       ; M device
M227h 2 3 1 0 NMOS L=1.00u W=13.8u       ; M device
C227i 2 1 695p                           ; C device
R227j 3 0 4.8M                           ; R device
M227k 0 2 3 1 PMOS L=0.13u W=57.0u       ; M device
R227l 0 1 697                            ; R device
C227m 1 0 0.4u                           ; C device
R227n 0 1 183                            ; R device
R227o 3 0 610                            ; R device
R227p 2 0 864                            ; R device
R227q 3 0 39k                            ; R device
M227r 0 1 2 3 PMOS L=0.10u W=92.9u AD=31.96p AS=149.13p PD=349.9u PS=332.8u ; M device
R227s 2 1 423                            ; R device
R227t 3 1 5.9M                           ; R device
C227u 1 2 836p                           ; C device
C227v 2 1 798p                           ; C device
M227w 0 3 2 1 NMOS L=0.50u W=11.5u AD=13.57p AS=2.69p PD=33.3u PS=36.8u ; M device
M227x 0 1 3 2 PMOS L=0.70u W=90.6u       ; M device
R227y 1 0 6k                             ; R device
M227z 1 2 0 3 PMOS L=0.18u W=43.9u AD=28.81p AS=58.93p PD=164.2u PS=172.9u ; M device
C228a 0 1 916p                           ; C device
M228b 3 1 2 0 NMOS L=0.35u W=14.0u       ; M device
M228c 1 0 3 2 NMOS L=0.25u W=53.9u
+ AD=51.29p AS=6.36p PD=128.4u PS=210.4u ; M device
C228d 3 1 81p                            ; C device
R228e 1 3 814                            ; R device
R228f 1 2 37k                            ; R device
M228g 3 2 1 0 NMOS L=0.10u W=15.9u
+ AD=25.58p AS=2.63p PD=54.1u PS=46.1u ; M device
R228h 0 3 8.5M                           ; R device
R228i 1 2 79k                            ; R device
R228j 2 1 6.3M                           ; R device
C228k 3 1 4.2m                           ; C device
C228l 2 3 576p                           ; C device
M228m 3 1 0 2 PMOS L=0.35u W=49.0u       ; M device
R228n 0 2 895                            ; R device
M228o 0 2 3 1 NMOS L=0.13u W=98.5u AD=152.45p AS=91.53p PD=227.5u PS=379.7u ; M device
C228p 0 3 5.4m                           ; C device
M228q 1 3 2 0 NMOS L=0.25u W=44.7u       ; M device
M228r 0 2 1 3 PMOS L=0.10u W=57.2u       ; M device
M228s 2 0 3 1 PMOS L=0.13u W=59.5u       ; M device
M228t 2 0 3 1 NMOS L=0.35u W=72.5u
+ AD=17.80p AS=113.11p PD=219.9u PS=266.5u ; M device
R228u 3 0 52k                            ; R device
C228v 0 3 75n                            ; C device
M228w 1 2 0 3 PMOS L=0.10u W=12.8u       ; M device
M228x 0 1 3 2 PMOS L=0.25u W=49.4u       ; M device
C228y 0 3 3.9u                           ; C device
C228z 1 3 3.7u                           ; C device
M229a 0 2 3 1 NMOS L=0.13u W=60.7u AD=73.03p AS=21.28p PD=228.8u PS=202.5u ; M device
M229b 3 2 0 1 NMOS L=0.70u W=73.3u AD=34.08p AS=66.31p PD=165.5u PS=198.3u ; M device
R229c 3 1 4.8M                           ; R device
C229d 3 1 89n                            ; C device
R229e 1 3 63k                            ; R device
R229f 0 1 89k                            ; R device
M229g 2 1 3 0 PMOS L=0.35u W=11.6u AD=21.99p AS=11.40p PD=36.3u PS=33.4u ; M device
R229h 1 3 902                            ; R device
R229i 0 3 3.4M                           ; R device
R229j 0 2 818                            ; R device
C229k 3 2 94n                            ; C device
C229l 0 1 2.6m                           ; C device
R229m 2 0 906                            ; R device
R229n 2 3 0.6M                           ; R device
M229o 3 1 0 2 NMOS L=0.18u W=76.8u       ; M device
C229p 2 0 7.6m                           ; C device
C229q 1 3 0.5u                           ; C device
R229r 1 3 302                            ; R device
R229s 3 2 6k                             ; R device
M229t 3 0 1 2 NMOS L=0.25u W=41.7u AD=72.90p AS=41.91p PD=134.1u PS=155.8u ; M device
M229u 3 0 1 2 PMOS L=0.10u W=16.2u       ; M device
M229v 1 2 0 3 NMOS L=0.50u W=81.2u AD=56.80p AS=24.80p PD=299.3u PS=268.7u ; M device
C229w 1 3 104p                           ; C device
C229x 2 1 35n                            ; C device
M229y 2 0 1 3 NMOS L=0.25u W=66.0u       ; M device
R229z 0 3 22k                            ; R device
M230a 3 1 0 2 PMOS L=1.00u W=51.7u
+ AD=11.20p AS=64.15p PD=117.1u PS=119.4u ; M device
M230b 1 2 3 0 PMOS L=0.35u W=12.8u       ; M device
R230c 3 2 5.6M                           ; R device
M230d 0 3 2 1 NMOS L=1.00u W=37.2u AD=6.98p AS=72.52p PD=146.9u PS=109.7u ; M device
M230e 0 1 3 2 PMOS L=0.10u W=97.9u AD=166.47p AS=106.45p PD=304.2u PS=336.1u ; M device
C230f 2 0 76n                            ; C device
M230g 2 1 3 0 PMOS L=1.00u W=46.6u AD=6.69p AS=52.66p PD=181.7u PS=136.4u ; M device
C230h 2 1 370p                           ; C device
M230i 1 0 3 2 PMOS L=0.50u W=7.0u
+ AD=7.48p AS=6.65p PD=23.8u PS=24.5u ; M device
M230j 3 0 2 1 NMOS L=0.13u W=19.2u       ; M device
R230k 1 0 714                            ; R device
R230l 3 2 16k                            ; R device
R230m 1 2 0.4M                           ; R device
M230n 2 3 1 0 PMOS L=0.13u W=51.2u       ; M device
R230o 0 1 0.8M                           ; R device
M230p 1 2 3 0 NMOS L=0.18u W=25.0u       ; M device
C230q 1 0 24n                            ; C device
C230r 2 3 162p                           ; C device
C230s 2 1 9.2u                           ; C device
R230t 3 2 3.6M                           ; R device
C230u 2 3 28n                            ; C device
C230v 3 1 76n                            ; C device
R230w 1 2 227                            ; R device
M230x 1 3 2 0 PMOS L=1.00u W=26.0u       ; M device
R230y 0 1 33k                            ; R device
R230z 1 0 671                            ; R device
M231a 1 3 0 2 PMOS L=0.25u W=71.9u
+ AD=24.12p AS=98.99p PD=172.7u PS=246.9u ; M device
R231b 3 1 938                            ; R device
M231c 1 3 0 2 PMOS L=0.50u W=15.9u AD=30.73p AS=20.17p PD=62.6u PS=49.2u ; M device
M231d 2 0 3 1 PMOS L=0.25u W=94.9u       ; M device
M231e 0 3 1 2 NMOS L=1.00u W=73.1u AD=15.63p AS=111.97p PD=155.7u PS=182.4u ; M device
M231f 0 1 3 2 NMOS L=0.18u W=97.3u
+ AD=105.09p AS=131.00p PD=385.6u PS=195.1u ; M device
M231g 3 1 2 0 PMOS L=0.50u W=66.8u       ; M device
C231h 2 1 41n                            ; C device
R231i 2 1 580                            ; R device
M231j 3 1 2 0 NMOS L=0.10u W=66.0u       ; M device
C231k 2 3 79n                            ; C device
M231l 0 2 3 1 NMOS L=0.18u W=90.9u
+ AD=26.70p AS=66.71p PD=199.3u PS=322.8u ; M device
C231m 2 3 5.9m                           ; C device
C231n 2 0 586p                           ; C device
R231o 2 0 259                            ; R device
M231p 1 2 0 3 NMOS L=0.35u W=81.8u       ; M device
R231q 0 1 5.4M                           ; R device
C231r 1 3 1.3u                           ; C device
R231s 0 3 65k                            ; R device
C231t 2 1 5.2u                           ; C device
R231u 1 2 44k                            ; R device
C231v 0 1 5.3m                           ; C device
R231w 0 3 507                            ; R device
M231x 0 3 2 1 PMOS L=0.35u W=80.9u
+ AD=9.49p AS=61.04p PD=237.2u PS=256.5u ; M device
C231y 2 1 2.2u                           ; C device
R231z 0 3 729                            ; R device
C232a 1 3 4.6m                           ; C device
C232b 0 2 394p                           ; C device
R232c 3 2 6k                             ; R device
M232d 2 3 0 1 PMOS L=0.35u W=43.7u       ; M device
M232e 2 3 0 1 PMOS L=0.13u W=89.8u       ; M device
C232f 2 1 8.0m                           ; C device
M232g 2 3 1 0 NMOS L=0.10u W=12.3u
+ AD=17.25p AS=19.25p PD=44.1u PS=39.8u ; M device
R232h 1 0 91k                            ; R device
R232i 0 2 185                            ; R device
M232j 2 0 3 1 NMOS L=0.13u W=33.9u AD=33.41p AS=33.33p PD=72.3u PS=94.9u ; M device
R232k 0 2 6.3M                           ; R device
R232l 0 1 385                            ; R device
M232m 1 3 0 2 PMOS L=0.10u W=98.2u
+ AD=113.59p AS=134.75p PD=227.3u PS=324.0u ; M device
C232n 3 2 11n                            ; C device
C232o 0 3 887p                           ; C device
C232p 2 0 4.9u                           ; C device
C232q 1 2 9.5m                           ; C device
C232r 3 1 6.4m                           ; C device
R232s 0 1 49k                            ; R device
R232t 2 3 993                            ; R device
C232u 0 1 63n                            ; C device
R232v 3 0 553                            ; R device
M232w 1 0 2 3 NMOS L=1.00u W=51.9u       ; M device
M232x 2 1 3 0 PMOS L=0.18u W=38.7u       ; M device
C232y 2 0 2.3m                           ; C device
M232z 1 2 0 3 PMOS L=0.35u W=85.5u AD=138.42p AS=76.89p PD=188.9u PS=263.0u ; M device
R233a 3 1 72k                            ; R device
C233b 1 2 52n                            ; C device
M233c 3 0 1 2 PMOS L=0.10u W=66.5u AD=105.38p AS=71.59p PD=214.4u PS=251.7u ; M device
R233d 2 1 700                            ; R device
R233e 2 0 5.3M                           ; R device
M233f 3 0 2 1 PMOS L=0.18u W=72.8u
+ AD=26.83p AS=42.60p PD=208.9u PS=172.6u ; M device
C233g 1 2 374p                           ; C device
C233h 0 3 2.4m                           ; C device
M233i 0 2 3 1 NMOS L=0.18u W=19.5u AD=21.71p AS=15.07p PD=48.6u PS=61.8u ; M device
M233j 1 2 0 3 NMOS L=0.25u W=95.6u       ; M device
R233k 2 1 77k                            ; R device
R233l 3 1 861                            ; R device
C233m 2 0 5.7u                           ; C device
R233n 2 3 85k                            ; R device
M233o 0 3 1 2 PMOS L=0.70u W=47.1u       ; M device
M233p 2 3 1 0 PMOS L=0.13u W=28.1u AD=31.16p AS=22.10p PD=83.1u PS=92.3u ; M device
M233q 3 2 0 1 NMOS L=0.50u W=63.7u       ; M device
M233r 2 1 0 3 NMOS L=0.18u W=89.2u
+ AD=16.38p AS=120.67p PD=252.9u PS=331.8u ; M device
R233s 2 1 710                            ; R device
C233t 2 3 4.3u                           ; C device
C233u 3 2 39n                            ; C device
R233v 0 2 29                             ; R device
R233w 3 1 2.5M                           ; R device
M233x 0 2 3 1 NMOS L=0.35u W=80.2u
+ AD=87.02p AS=29.19p PD=188.3u PS=250.1u ; M device
R233y 1 0 520                            ; R device
R233z 2 3 941                            ; R device
C234a 0 1 4.2u                           ; C device
C234b 3 0 703p                           ; C device
M234c 3 2 1 0 NMOS L=0.35u W=51.7u AD=48.72p AS=10.82p PD=138.7u PS=164.8u ; M device
R234d 2 1 25k                            ; R device
R234e 2 1 73k                            ; R device
M234f 3 1 0 2 PMOS L=0.50u W=46.2u       ; M device
R234g 3 0 87k                            ; R device
R234h 3 2 5.0M                           ; R device
R234i 2 1 3.7M                           ; R device
M234j 2 1 3 0 PMOS L=0.25u W=14.5u
+ AD=4.60p AS=13.68p PD=41.2u PS=33.4u ; M device
M234k 0 3 2 1 NMOS L=0.10u W=95.4u       ; M device
R234l 1 3 50k                            ; R device
M234m 2 0 3 1 NMOS L=0.10u W=33.1u       ; M device
M234n 1 2 3 0 PMOS L=0.70u W=85.3u
+ AD=14.85p AS=125.05p PD=201.9u PS=176.9u ; M device
R234o 2 0 33                             ; R device
R234p 3 2 9.7M                           ; R device
M234q 1 0 2 3 NMOS L=1.00u W=19.9u
+ AD=31.61p AS=19.32p PD=75.8u PS=75.0u ; M device
M234r 1 3 0 2 NMOS L=0.18u W=60.0u
+ AD=112.16p AS=54.86p PD=135.7u PS=212.5u ; M device
M234s 3 1 0 2 NMOS L=0.35u W=64.4u AD=17.62p AS=41.62p PD=133.8u PS=175.8u ; M device
C234t 1 2 73n                            ; C device
R234u 1 2 444                            ; R device
M234v 1 0 3 2 NMOS L=1.00u W=34.5u AD=47.17p AS=53.91p PD=70.4u PS=121.0u ; M device
R234w 2 3 8.8M                           ; R device
C234x 3 0 912p                           ; C device
C234y 1 2 8.4u                           ; C device
C234z 0 1 2.9m                           ; C device
R235a 2 3 48k                            ; R device
M235b 2 0 3 1 NMOS L=0.35u W=51.7u       ; M device
R235c 3 0 681                            ; R device
R235d 3 2 58k                            ; R device
M235e 2 1 3 0 PMOS L=0.35u W=52.5u       ; M device
R235f 3 1 528                            ; R device
M235g 0 3 1 2 PMOS L=0.25u W=86.9u
+ AD=140.63p AS=134.88p PD=234.5u PS=239.1u ; M device
M235h 2 3 0 1 NMOS L=0.18u W=18.0u       ; M device
C235i 2 1 3.6m                           ; C device
R235j 2 3 0.9M                           ; R device
C235k 3 2 6.1m                           ; C device
M235l 0 2 3 1 PMOS L=0.13u W=46.8u AD=32.18p AS=64.99p PD=163.0u PS=181.4u ; M device
R235m 2 0 2.0M                           ; R device
M235n 2 1 0 3 NMOS L=0.50u W=56.5u       ; M device
R235o 1 2 90k                            ; R device
M235p 2 1 0 3 NMOS L=0.35u W=87.3u       ; M device
C235q 1 3 0.4m                           ; C device
C235r 0 1 47n                            ; C device
R235s 1 0 195                            ; R device
M235t 3 2 0 1 PMOS L=0.13u W=13.4u       ; M device
R235u 2 1 4.3M                           ; R device
R235v 0 1 8.4M                           ; R device
M235w 2 0 1 3 PMOS L=0.10u W=80.6u       ; M device
C235x 1 3 59n                            ; C device
M235y 1 0 2 3 NMOS L=1.00u W=55.4u       ; M device
M235z 2 0 3 1 PMOS L=0.50u W=94.7u       ; M device
M236a 0 2 3 1 NMOS L=0.18u W=11.3u
+ AD=18.54p AS=3.72p PD=31.0u PS=29.4u ; M device
R236b 2 3 1.3M                           ; R device
M236c 3 0 2 1 NMOS L=1.00u W=51.2u       ; M device
M236d 1 2 0 3 PMOS L=0.35u W=20.8u       ; M device
R236e 1 0 15k                            ; R device
R236f 0 1 234                            ; R device
M236g 2 1 0 3 PMOS L=0.50u W=36.8u       ; M device
C236h 2 0 314p                           ; C device
M236i 1 2 3 0 NMOS L=0.10u W=33.2u       ; M device
M236j 3 2 1 0 PMOS L=0.13u W=88.6u       ; M device
C236k 3 2 0.6m                           ; C device
R236l 0 1 972                            ; R device
M236m 1 2 0 3 PMOS L=0.10u W=48.9u
+ AD=79.70p AS=75.35p PD=102.7u PS=142.3u ; M device
R236n 1 0 4.7M                           ; R device
M236o 3 2 1 0 PMOS L=1.00u W=48.5u AD=26.98p AS=88.93p PD=108.9u PS=172.8u ; M device
R236p 1 3 679                            ; R device
M236q 2 3 0 1 PMOS L=1.00u W=86.5u
+ AD=38.67p AS=126.80p PD=207.9u PS=332.0u ; M device
R236r 2 3 909                            ; R device
M236s 3 1 0 2 PMOS L=0.13u W=83.2u AD=112.20p AS=8.37p PD=247.4u PS=331.5u ; M device
R236t 1 0 2                              ; R device
M236u 2 3 1 0 PMOS L=0.10u W=3.3u AD=6.57p AS=3.83p PD=11.8u PS=8.0u ; M device
R236v 1 0 2.5M                           ; R device
R236w 2 1 0.8M                           ; R device
R236x 2 3 6.4M                           ; R device
R236y 1 2 501                            ; R device
M236z 1 3 0 2 PMOS L=0.35u W=56.0u       ; M device
C237a 2 3 78n                            ; C device
R237b 0 2 444                            ; R device
C237c 0 1 279p                           ; C device
C237d 3 2 6.1m                           ; C device
R237e 2 0 67k                            ; R device
R237f 3 0 76k                            ; R device
C237g 1 2 10.0m                          ; C device
C237h 3 2 5.7u                           ; C device
C237i 3 2 9.9u                           ; C device
C237j 0 2 79n                            ; C device
C237k 3 0 34n                            ; C device
C237l 1 3 90n                            ; C device
C237m 0 1 769p                           ; C device
C237n 0 2 1.2u                           ; C device
M237o 3 0 2 1 NMOS L=0.25u W=38.0u
+ AD=16.42p AS=69.32p PD=116.6u PS=85.1u ; M device
R237p 2 3 1.7M                           ; R device
M237q 1 3 2 0 NMOS L=0.35u W=10.8u
+ AD=4.02p AS=2.00p PD=42.1u PS=41.7u ; M device
M237r 0 2 3 1 PMOS L=0.13u W=0.6u        ; M device
R237s 0 3 9.7M                           ; R device
M237t 0 2 3 1 PMOS L=0.25u W=19.6u
+ AD=5.94p AS=9.34p PD=73.9u PS=65.2u ; M device
M237u 1 2 3 0 NMOS L=0.18u W=44.1u AD=40.91p AS=72.88p PD=104.5u PS=150.2u ; M device
M237v 2 0 3 1 NMOS L=0.25u W=94.0u       ; M device
M237w 1 2 0 3 PMOS L=0.18u W=89.7u       ; M device
R237x 2 3 605                            ; R device
M237y 0 1 3 2 PMOS L=1.00u W=77.4u       ; M device
C237z 0 2 9.9u                           ; C device
M238a 0 3 2 1 NMOS L=0.13u W=10.5u       ; M device
C238b 2 3 4.9u                           ; C device
M238c 1 2 0 3 NMOS L=0.35u W=78.5u       ; M device
C238d 0 3 104p                           ; C device
R238e 0 1 43k                            ; R device
R238f 3 2 85k                            ; R device
M238g 2 1 0 3 NMOS L=1.00u W=91.2u
+ AD=95.85p AS=43.92p PD=307.0u PS=249.6u ; M device
C238h 3 1 751p                           ; C device
R238i 2 1 345                            ; R device
M238j 0 3 1 2 PMOS L=0.25u W=6.1u
+ AD=7.43p AS=3.92p PD=21.5u PS=22.2u ; M device
C238k 0 1 811p                           ; C device
R238l 1 0 68k                            ; R device
M238m 3 1 2 0 PMOS L=0.70u W=69.7u AD=90.61p AS=113.59p PD=142.4u PS=160.6u ; M device
M238n 2 1 3 0 PMOS L=0.35u W=52.8u       ; M device
C238o 1 0 9.6u                           ; C device
R238p 0 1 43k                            ; R device
C238q 3 2 7n                             ; C device
M238r 3 2 0 1 NMOS L=0.70u W=84.7u       ; M device
R238s 0 3 35k                            ; R device
M238t 0 1 3 2 PMOS L=0.18u W=20.4u
+ AD=8.35p AS=39.52p PD=70.9u PS=49.1u ; M device
M238u 0 3 2 1 PMOS L=0.18u W=56.6u
+ AD=66.85p AS=77.35p PD=157.4u PS=143.6u ; M device
R238v 2 1 6.7M                           ; R device
M238w 2 0 3 1 NMOS L=1.00u W=91.9u       ; M device
C238x 3 0 8.4m                           ; C device
M238y 1 0 2 3 PMOS L=0.18u W=8.2u        ; M device
C238z 2 1 79n                            ; C device
R239a 3 1 0.6M                           ; R device
R239b 0 3 68k                            ; R device
C239c 1 3 7.4m                           ; C device
M239d 0 3 2 1 PMOS L=0.18u W=70.2u AD=95.28p AS=20.02p PD=242.6u PS=205.1u ; M device
R239e 3 0 190                            ; R device
M239f 1 0 3 2 NMOS L=0.25u W=7.6u        ; M device
M239g 0 3 2 1 NMOS L=0.35u W=61.4u AD=50.10p AS=71.47p PD=198.7u PS=172.9u ; M device
R239h 3 2 9.0M                           ; R device
C239i 3 1 635p                           ; C device
C239j 3 1 5.8u                           ; C device
M239k 3 0 2 1 PMOS L=1.00u W=62.6u
+ AD=104.23p AS=55.53p PD=202.9u PS=144.5u ; M device
R239l 2 3 1.7M                           ; R device
C239m 1 0 0.5u                           ; C device
M239n 0 2 1 3 NMOS L=0.70u W=64.2u AD=42.56p AS=88.09p PD=234.2u PS=227.6u ; M device
M239o 0 1 2 3 NMOS L=1.00u W=21.3u       ; M device
R239p 0 1 27k                            ; R device
C239q 1 0 5.7m                           ; C device
R239r 3 2 667                            ; R device
M239s 1 0 2 3 NMOS L=0.18u W=29.2u AD=39.09p AS=32.13p PD=81.0u PS=63.6u ; M device
M239t 3 0 2 1 PMOS L=0.25u W=21.1u       ; M device
R239u 2 3 7.9M                           ; R device
C239v 1 2 2n                             ; C device
C239w 0 1 548p                           ; C device
M239x 2 3 0 1 PMOS L=0.25u W=85.3u       ; M device
C239y 3 1 6.6m                           ; C device
C239z 3 2 2.2m                           ; C device
C240a 3 2 446p                           ; C device
R240b 0 3 37                             ; R device
R240c 2 0 290                            ; R device
C240d 3 0 92n                            ; C device
C240e 2 3 782p                           ; C device
C240f 2 0 4.7u                           ; C device
M240g 2 1 3 0 PMOS L=0.35u W=81.5u AD=75.15p AS=85.73p PD=211.3u PS=226.6u ; M device
C240h 1 0 4.1u                           ; C device
C240i 3 2 33p                            ; C device
C240j 0 2 59n                            ; C device
M240k 0 3 1 2 PMOS L=0.10u W=72.4u
+ AD=13.20p AS=40.67p PD=277.5u PS=146.4u ; M device
C240l 0 1 68n                            ; C device
M240m 3 1 0 2 NMOS L=0.13u W=6.2u AD=1.88p AS=9.77p PD=18.4u PS=23.8u ; M device
R240n 1 2 0.5M                           ; R device
M240o 1 0 3 2 PMOS L=0.13u W=49.6u
+ AD=54.76p AS=78.06p PD=105.1u PS=119.7u ; M device
M240p 1 0 3 2 PMOS L=0.18u W=17.9u       ; M device
M240q 0 1 2 3 PMOS L=0.70u W=33.4u       ; M device
C240r 2 1 325p                           ; C device
C240s 2 3 68p                            ; C device
C240t 3 1 2.9u                           ; C device
R240u 0 2 100k                           ; R device
R240v 0 2 135                            ; R device
C240w 2 0 8.9u                           ; C device
M240x 3 0 1 2 NMOS L=0.70u W=30.3u       ; M device
R240y 0 3 3.8M                           ; R device
M240z 2 3 0 1 NMOS L=0.10u W=31.0u       ; M device
C241a 2 0 9.7m                           ; C device
M241b 1 0 3 2 PMOS L=0.25u W=56.4u       ; M device
R241c 3 1 757                            ; R device
C241d 1 2 4n                             ; C device
R241e 0 2 474                            ; R device
R241f 1 3 3.3M                           ; R device
M241g 2 3 0 1 PMOS L=0.50u W=9.4u
+ AD=2.74p AS=1.06p PD=30.7u PS=28.6u ; M device
M241h 2 0 1 3 NMOS L=0.50u W=15.4u
+ AD=4.24p AS=22.74p PD=34.9u PS=53.6u ; M device
M241i 2 0 3 1 PMOS L=0.25u W=41.3u       ; M device
M241j 0 3 1 2 NMOS L=0.13u W=83.6u       ; M device
C241k 2 3 2.1u                           ; C device
R241l 0 1 4.9M                           ; R device
C241m 2 3 56n                            ; C device
C241n 3 2 73n                            ; C device
R241o 3 1 10k                            ; R device
M241p 3 1 2 0 PMOS L=0.50u W=41.2u AD=56.85p AS=66.91p PD=91.2u PS=100.4u ; M device
C241q 3 1 807p                           ; C device
M241r 2 3 1 0 NMOS L=1.00u W=81.3u
+ AD=30.77p AS=54.21p PD=225.0u PS=210.7u ; M device
M241s 1 2 3 0 PMOS L=1.00u W=72.1u AD=77.16p AS=72.50p PD=205.8u PS=156.1u ; M device
R241t 0 3 5.8M                           ; R device
R241u 2 1 5.9M                           ; R device
M241v 2 3 0 1 NMOS L=1.00u W=99.1u AD=31.76p AS=184.60p PD=200.9u PS=349.7u ; M device
R241w 1 2 75k                            ; R device
R241x 1 3 77k                            ; R device
C241y 3 2 2.3m                           ; C device
R241z 0 2 6.3M                           ; R device
C242a 1 3 604p                           ; C device
R242b 0 2 25k                            ; R device
C242c 0 3 3.5m                           ; C device
R242d 1 0 83                             ; R device
R242e 2 0 21k                            ; R device
R242f 2 0 55k                            ; R device
R242g 0 3 85k                            ; R device
C242h 3 2 1.3m                           ; C device
R242i 2 1 13k                            ; R device
M242j 2 0 1 3 PMOS L=0.25u W=71.7u       ; M device
M242k 2 1 0 3 PMOS L=1.00u W=96.1u
+ AD=182.47p AS=117.86p PD=267.8u PS=213.1u ; M device
M242l 2 0 3 1 NMOS L=0.35u W=26.3u       ; M device
R242m 1 2 97k                            ; R device
M242n 1 3 0 2 NMOS L=1.00u W=32.1u       ; M device
R242o 0 1 1.6M                           ; R device
R242p 2 3 658                            ; R device
C242q 0 3 1.5m                           ; C device
M242r 3 0 2 1 NMOS L=0.25u W=46.6u AD=10.14p AS=71.54p PD=126.1u PS=139.5u ; M device
R242s 1 3 99k                            ; R device
R242t 3 0 69k                            ; R device
C242u 1 3 0.1m                           ; C device
R242v 3 1 46k                            ; R device
M242w 1 3 0 2 NMOS L=0.70u W=16.2u AD=20.04p AS=10.65p PD=36.9u PS=64.5u ; M device
M242x 1 3 2 0 PMOS L=0.18u W=6.8u
+ AD=5.14p AS=12.48p PD=14.5u PS=18.9u ; M device
R242y 1 3 7.7M                           ; R device
R242z 2 0 228                            ; R device
R243a 3 0 434                            ; R device
C243b 2 1 77n                            ; C device
R243c 2 1 1.8M                           ; R device
C243d 1 2 65n                            ; C device
R243e 3 1 4.2M                           ; R device
M243f 1 0 3 2 PMOS L=0.18u W=74.3u       ; M device
C243g 0 3 92n                            ; C device
R243h 0 3 422                            ; R device
R243i 0 2 369                            ; R device
M243j 1 0 2 3 PMOS L=0.10u W=46.9u
+ AD=15.75p AS=81.93p PD=95.2u PS=166.2u ; M device
R243k 0 3 15k                            ; R device
C243l 3 1 382p                           ; C device
M243m 2 3 1 0 PMOS L=0.70u W=86.8u
+ AD=27.19p AS=81.71p PD=306.7u PS=180.7u ; M device
M243n 1 3 2 0 NMOS L=0.13u W=19.1u AD=27.26p AS=15.31p PD=55.0u PS=73.1u ; M device
C243o 3 1 450p                           ; C device
M243p 1 0 3 2 NMOS L=0.50u W=32.0u       ; M device
M243q 1 2 0 3 PMOS L=0.25u W=68.8u       ; M device
C243r 3 0 623p                           ; C device
C243s 2 3 66p                            ; C device
C243t 0 1 1.5m                           ; C device
R243u 0 1 99k                            ; R device
C243v 2 0 6.6u                           ; C device
M243w 0 2 1 3 PMOS L=0.50u W=64.4u
+ AD=69.65p AS=16.31p PD=178.6u PS=203.6u ; M device
R243x 0 2 7.4M                           ; R device
C243y 0 1 78n                            ; C device
M243z 0 1 3 2 NMOS L=0.18u W=50.7u AD=78.76p AS=39.11p PD=140.2u PS=115.8u ; M device
R244a 1 3 3.7M                           ; R device
M244b 3 0 2 1 NMOS L=0.18u W=56.8u
+ AD=70.24p AS=6.25p PD=171.9u PS=183.2u ; M device
M244c 1 3 2 0 NMOS L=0.10u W=40.1u       ; M device
R244d 0 2 489                            ; R device
M244e 0 1 3 2 NMOS L=0.10u W=14.6u
+ AD=10.40p AS=27.00p PD=56.5u PS=47.1u ; M device
R244f 2 1 5.7M                           ; R device
C244g 3 0 680p                           ; C device
C244h 3 1 81p                            ; C device
M244i 3 2 1 0 NMOS L=0.10u W=69.7u       ; M device
M244j 2 0 3 1 PMOS L=0.70u W=90.5u AD=41.31p AS=179.52p PD=198.5u PS=337.0u ; M device
R244k 2 3 646                            ; R device
R244l 2 3 9.2M                           ; R device
R244m 0 3 64k                            ; R device
M244n 1 0 3 2 NMOS L=0.25u W=78.0u
+ AD=42.73p AS=46.63p PD=256.4u PS=199.0u ; M device
C244o 3 2 43n                            ; C device
R244p 3 0 1.0M                           ; R device
M244q 0 3 2 1 PMOS L=0.25u W=43.1u AD=4.46p AS=38.32p PD=88.6u PS=129.9u ; M device
M244r 2 3 1 0 PMOS L=0.25u W=62.9u
+ AD=80.68p AS=13.98p PD=151.0u PS=156.2u ; M device
M244s 2 0 3 1 PMOS L=0.25u W=84.9u
+ AD=73.20p AS=158.09p PD=330.0u PS=198.8u ; M device
C244t 0 2 52n                            ; C device
M244u 0 3 2 1 NMOS L=0.35u W=97.5u       ; M device
R244v 0 3 21k                            ; R device
M244w 0 1 2 3 PMOS L=0.18u W=35.0u
+ AD=23.33p AS=67.44p PD=72.9u PS=139.8u ; M device
R244x 2 3 34k                            ; R device
C244y 2 1 59n                            ; C device
M244z 1 0 3 2 NMOS L=0.70u W=20.4u       ; M device
C245a 0 3 3.4m                           ; C device
M245b 3 0 2 1 PMOS L=0.25u W=17.7u AD=16.10p AS=23.20p PD=63.8u PS=49.3u ; M device
C245c 3 0 1.9m                           ; C device
C245d 2 1 2.5u                           ; C device
C245e 0 2 7.9u                           ; C device
M245f 2 1 3 0 PMOS L=0.70u W=52.8u
+ AD=32.62p AS=30.14p PD=176.5u PS=127.9u ; M device
C245g 3 1 23n                            ; C device
M245h 0 1 2 3 PMOS L=0.13u W=45.5u       ; M device
R245i 2 3 782                            ; R device
M245j 2 3 0 1 NMOS L=0.35u W=39.5u AD=63.56p AS=21.19p PD=116.1u PS=95.7u ; M device
M245k 3 2 1 0 PMOS L=0.10u W=6.8u AD=3.62p AS=1.32p PD=26.1u PS=20.2u ; M device
C245l 2 1 50n                            ; C device
R245m 3 1 20k                            ; R device
M245n 2 3 0 1 NMOS L=0.25u W=61.1u
+ AD=40.51p AS=21.00p PD=137.6u PS=137.8u ; M device
R245o 1 3 89k                            ; R device
M245p 2 3 1 0 NMOS L=1.00u W=77.3u
+ AD=125.53p AS=150.08p PD=242.1u PS=160.8u ; M device
C245q 3 2 3.1u                           ; C device
M245r 2 3 0 1 NMOS L=0.13u W=25.1u AD=22.39p AS=22.93p PD=63.0u PS=64.5u ; M device
R245s 1 3 245                            ; R device
R245t 1 3 628                            ; R device
C245u 3 1 31n                            ; C device
M245v 0 3 1 2 NMOS L=0.25u W=65.6u       ; M device
R245w 3 2 428                            ; R device
R245x 0 2 8.7M                           ; R device
R245y 1 0 882                            ; R device
M245z 0 2 3 1 PMOS L=0.13u W=46.6u AD=86.45p AS=67.50p PD=115.0u PS=178.0u ; M device
C246a 3 0 81n                            ; C device
M246b 1 2 3 0 NMOS L=0.13u W=95.3u
+ AD=108.85p AS=61.61p PD=212.0u PS=227.8u ; M device
R246c 3 0 366                            ; R device
C246d 1 0 0.3m                           ; C device
M246e 0 3 2 1 PMOS L=0.25u W=45.8u       ; M device
M246f 0 3 2 1 NMOS L=1.00u W=31.9u
+ AD=34.73p AS=57.23p PD=72.2u PS=122.5u ; M device
C246g 2 0 314p                           ; C device
R246h 3 0 7.3M                           ; R device
M246i 2 3 0 1 NMOS L=0.70u W=3.2u AD=6.31p AS=0.37p PD=12.5u PS=10.7u ; M device
R246j 2 0 9.4M                           ; R device
R246k 2 1 500                            ; R device
M246l 3 2 1 0 NMOS L=0.25u W=0.8u
+ AD=1.27p AS=0.20p PD=2.6u PS=1.5u ; M device
C246m 1 0 9.5m                           ; C device
C246n 0 1 945p                           ; C device
R246o 2 3 8.8M                           ; R device
M246p 0 3 1 2 PMOS L=0.18u W=51.6u       ; M device
R246q 2 1 6.8M                           ; R device
M246r 3 2 0 1 PMOS L=0.13u W=65.7u       ; M device
R246s 1 2 55k                            ; R device
R246t 0 1 720                            ; R device
C246u 0 2 70n                            ; C device
M246v 2 3 0 1 NMOS L=0.50u W=84.6u AD=32.92p AS=156.17p PD=277.2u PS=269.4u ; M device
M246w 2 0 1 3 PMOS L=1.00u W=54.3u       ; M device
C246x 2 1 338p                           ; C device
R246y 1 3 270                            ; R device
R246z 1 3 9.6M                           ; R device
C247a 2 1 9.3m                           ; C device
R247b 1 3 716                            ; R device
C247c 1 0 89n                            ; C device
R247d 0 2 127                            ; R device
M247e 1 3 2 0 PMOS L=0.10u W=63.9u AD=85.18p AS=22.48p PD=132.9u PS=191.1u ; M device
R247f 3 2 982                            ; R device
R247g 3 2 775                            ; R device
R247h 2 3 18k                            ; R device
C247i 1 2 32p                            ; C device
C247j 3 2 9.6u                           ; C device
M247k 1 2 3 0 NMOS L=0.18u W=70.2u
+ AD=109.54p AS=129.83p PD=222.2u PS=178.9u ; M device
M247l 0 1 3 2 NMOS L=0.18u W=8.5u AD=15.19p AS=13.55p PD=25.2u PS=33.3u ; M device
M247m 3 0 2 1 PMOS L=1.00u W=6.9u        ; M device
R247n 0 2 85                             ; R device
M247o 1 0 3 2 PMOS L=0.70u W=98.0u AD=143.52p AS=63.15p PD=297.2u PS=278.7u ; M device
M247p 2 1 3 0 NMOS L=0.10u W=59.0u       ; M device
M247q 2 1 0 3 NMOS L=0.35u W=32.1u AD=18.12p AS=19.80p PD=85.7u PS=90.8u ; M device
R247r 2 0 5.9M                           ; R device
R247s 1 2 40k                            ; R device
M247t 0 1 3 2 NMOS L=1.00u W=49.1u       ; M device
C247u 1 3 802p                           ; C device
C247v 2 1 0.3u                           ; C device
R247w 2 3 3.7M                           ; R device
M247x 3 0 1 2 PMOS L=0.70u W=42.7u AD=37.90p AS=14.35p PD=125.0u PS=118.4u ; M device
C247y 3 1 59n                            ; C device
M247z 1 0 2 3 NMOS L=0.18u W=70.4u       ; M device
M248a 1 2 3 0 PMOS L=0.10u W=11.6u
+ AD=14.45p AS=18.48p PD=40.1u PS=25.0u ; M device
R248b 2 3 1.1M                           ; R device
C248c 3 0 4.6m                           ; C device
C248d 0 3 21n                            ; C device
R248e 2 1 75k                            ; R device
M248f 3 2 1 0 PMOS L=0.10u W=37.9u
+ AD=21.25p AS=46.17p PD=129.0u PS=151.2u ; M device
M248g 3 0 2 1 PMOS L=0.25u W=33.2u       ; M device
R248h 3 1 267                            ; R device
C248i 1 0 790p                           ; C device
C248j 2 3 76n                            ; C device
M248k 1 0 2 3 NMOS L=1.00u W=30.4u AD=46.09p AS=6.52p PD=104.1u PS=121.2u ; M device
M248l 1 0 2 3 NMOS L=0.13u W=63.7u
+ AD=47.05p AS=16.61p PD=246.5u PS=185.9u ; M device
C248m 1 3 6.3u                           ; C device
C248n 1 3 2.4u                           ; C device
M248o 2 3 0 1 PMOS L=0.35u W=72.2u       ; M device
M248p 0 1 2 3 PMOS L=0.50u W=1.8u        ; M device
M248q 3 0 2 1 NMOS L=0.70u W=90.6u       ; M device
M248r 0 3 1 2 PMOS L=0.10u W=19.6u
+ AD=38.96p AS=12.41p PD=64.0u PS=63.0u ; M device
M248s 2 1 0 3 NMOS L=0.35u W=29.9u AD=56.99p AS=29.53p PD=87.1u PS=98.6u ; M device
R248t 1 3 442                            ; R device
C248u 1 3 890p                           ; C device
R248v 3 1 1.8M                           ; R device
M248w 0 2 1 3 NMOS L=0.13u W=25.4u AD=17.62p AS=29.28p PD=61.1u PS=65.1u ; M device
C248x 3 0 8.3u                           ; C device
C248y 3 2 9.4m                           ; C device
R248z 1 0 9.0M                           ; R device
R249a 2 1 5.6M                           ; R device
C249b 0 2 2.3m                           ; C device
C249c 3 2 9.9u                           ; C device
C249d 1 2 1.7m                           ; C device
R249e 1 2 13k                            ; R device
C249f 2 0 8.8m                           ; C device
R249g 1 0 137                            ; R device
C249h 3 0 7.0u                           ; C device
M249i 3 2 0 1 NMOS L=0.70u W=14.3u       ; M device
C249j 2 0 56n                            ; C device
R249k 0 3 7.4M                           ; R device
C249l 3 1 58n                            ; C device
C249m 0 3 44n                            ; C device
R249n 0 2 69k                            ; R device
R249o 0 2 792                            ; R device
C249p 0 3 601p                           ; C device
M249q 1 3 2 0 PMOS L=0.10u W=58.7u       ; M device
R249r 1 0 449                            ; R device
R249s 1 3 6.0M                           ; R device
C249t 1 0 3.1m                           ; C device
M249u 0 1 3 2 NMOS L=0.25u W=0.7u        ; M device
M249v 3 1 0 2 PMOS L=1.00u W=60.3u AD=39.82p AS=64.90p PD=124.7u PS=131.3u ; M device
M249w 2 1 0 3 NMOS L=0.70u W=82.6u
+ AD=56.48p AS=31.20p PD=215.3u PS=180.4u ; M device
M249x 2 0 1 3 PMOS L=0.13u W=61.2u       ; M device
C249y 1 0 5.5m                           ; C device
R249z 3 2 92k                            ; R device
C250a 1 0 200p                           ; C device
C250b 0 1 4.6u                           ; C device
M250c 0 3 2 1 NMOS L=0.18u W=2.1u        ; M device
R250d 1 3 66k                            ; R device
M250e 3 1 0 2 PMOS L=1.00u W=84.5u AD=163.47p AS=113.73p PD=249.4u PS=213.2u ; M device
R250f 3 1 96k                            ; R device
M250g 1 0 3 2 NMOS L=0.35u W=15.4u       ; M device
M250h 0 2 3 1 PMOS L=0.13u W=51.4u       ; M device
R250i 2 3 140                            ; R device
R250j 3 2 7k                             ; R device
R250k 0 2 48k                            ; R device
R250l 3 1 976                            ; R device
M250m 2 1 0 3 PMOS L=0.35u W=54.7u AD=48.67p AS=10.41p PD=163.2u PS=208.6u ; M device
R250n 2 3 129                            ; R device
M250o 0 1 3 2 PMOS L=0.18u W=9.9u AD=10.10p AS=4.84p PD=22.2u PS=32.6u ; M device
C250p 1 0 7.3m                           ; C device
M250q 0 2 1 3 NMOS L=0.70u W=55.6u       ; M device
M250r 0 2 1 3 NMOS L=0.10u W=50.6u
+ AD=57.90p AS=44.38p PD=111.5u PS=110.5u ; M device
M250s 0 2 1 3 PMOS L=0.70u W=80.0u
+ AD=118.92p AS=31.16p PD=189.5u PS=319.2u ; M device
R250t 0 1 83k                            ; R device
M250u 3 0 2 1 NMOS L=1.00u W=98.0u AD=62.17p AS=128.68p PD=240.6u PS=265.9u ; M device
M250v 1 0 2 3 PMOS L=0.50u W=92.5u       ; M device
R250w 0 1 792                            ; R device
C250x 2 1 2.6u                           ; C device
M250y 3 0 2 1 PMOS L=1.00u W=65.5u AD=121.12p AS=128.93p PD=166.6u PS=222.6u ; M device
R250z 0 1 299                            ; R device
C251a 2 3 8.4m                           ; C device
R251b 2 3 1.6M                           ; R device
C251c 3 2 96p                            ; C device
R251d 2 1 3.7M                           ; R device
C251e 0 2 11n                            ; C device
M251f 2 0 3 1 NMOS L=0.13u W=47.4u       ; M device
R251g 1 3 2.2M                           ; R device
M251h 0 3 1 2 NMOS L=0.70u W=57.3u AD=107.60p AS=97.87p PD=158.6u PS=207.5u ; M device
M251i 3 1 0 2 PMOS L=0.35u W=77.6u       ; M device
C251j 2 0 6.5m                           ; C device
R251k 0 3 87k                            ; R device
R251l 3 0 13                             ; R device
C251m 3 1 5.7u                           ; C device
C251n 2 3 591p                           ; C device
C251o 3 0 2.4u                           ; C device
M251p 1 2 0 3 NMOS L=0.35u W=14.7u       ; M device
C251q 2 3 915p                           ; C device
C251r 0 3 4.4m                           ; C device
M251s 1 2 0 3 NMOS L=0.10u W=67.0u
+ AD=132.76p AS=85.74p PD=227.8u PS=171.6u ; M device
M251t 1 2 3 0 NMOS L=0.25u W=75.8u AD=22.30p AS=146.68p PD=275.4u PS=191.7u ; M device
R251u 1 2 71k                            ; R device
C251v 3 1 3.8u                           ; C device
R251w 2 1 254                            ; R device
C251x 3 1 66n                            ; C device
M251y 0 3 2 1 NMOS L=0.35u W=95.4u       ; M device
R251z 3 0 1.1M                           ; R device
R252a 3 2 2.4M                           ; R device
M252b 0 3 1 2 NMOS L=0.35u W=88.3u       ; M device
C252c 2 3 0.4m                           ; C device
M252d 2 3 0 1 NMOS L=0.50u W=22.3u       ; M device
M252e 3 0 2 1 PMOS L=0.35u W=58.2u
+ AD=13.73p AS=24.00p PD=204.7u PS=130.8u ; M device
R252f 0 3 633                            ; R device
R252g 0 2 226                            ; R device
M252h 0 3 1 2 PMOS L=0.10u W=16.1u       ; M device
C252i 2 0 45n                            ; C device
R252j 1 0 5.1M                           ; R device
R252k 1 0 6.7M                           ; R device
C252l 2 1 67n                            ; C device
C252m 3 1 8.4m                           ; C device
R252n 0 1 27k                            ; R device
M252o 2 0 1 3 NMOS L=1.00u W=96.0u
+ AD=67.58p AS=10.82p PD=332.0u PS=292.7u ; M device
R252p 1 2 631                            ; R device
C252q 3 0 46n                            ; C device
R252r 0 2 7.3M                           ; R device
C252s 1 3 7.2m                           ; C device
C252t 2 1 4.4u                           ; C device
R252u 1 3 267                            ; R device
C252v 0 2 97n                            ; C device
R252w 3 0 4.8M                           ; R device
C252x 1 0 6n                             ; C device
R252y 3 2 8.8M                           ; R device
C252z 2 3 702p                           ; C device
R253a 0 2 11k                            ; R device
R253b 2 3 730                            ; R device
M253c 3 1 0 2 PMOS L=1.00u W=85.1u AD=147.52p AS=102.82p PD=293.4u PS=337.4u ; M device
R253d 2 1 3.8M                           ; R device
M253e 0 3 2 1 NMOS L=0.13u W=87.1u AD=88.07p AS=87.98p PD=270.1u PS=274.4u ; M device
R253f 0 1 7.6M                           ; R device
C253g 1 0 13n                            ; C device
R253h 2 0 88k                            ; R device
R253i 1 2 86                             ; R device
M253j 0 2 1 3 PMOS L=0.35u W=99.2u
+ AD=21.61p AS=42.93p PD=258.2u PS=305.3u ; M device
M253k 2 0 1 3 NMOS L=0.18u W=98.5u AD=86.08p AS=47.07p PD=315.0u PS=228.8u ; M device
R253l 0 2 9.6M                           ; R device
C253m 1 2 0.3u                           ; C device
C253n 1 3 45n                            ; C device
R253o 3 2 19k                            ; R device
C253p 1 2 18n                            ; C device
R253q 2 0 232                            ; R device
R253r 2 0 4.4M                           ; R device
C253s 3 1 5.9u                           ; C device
M253t 1 3 2 0 PMOS L=1.00u W=70.9u       ; M device
C253u 2 1 138p                           ; C device
M253v 3 1 0 2 NMOS L=0.50u W=1.3u        ; M device
R253w 3 1 101                            ; R device
R253x 3 2 49k                            ; R device
R253y 2 0 63k                            ; R device
M253z 2 0 1 3 PMOS L=0.50u W=50.8u       ; M device
M254a 1 2 3 0 NMOS L=1.00u W=3.4u        ; M device
M254b 3 2 0 1 NMOS L=0.50u W=33.1u AD=55.42p AS=6.84p PD=122.3u PS=95.0u ; M device
C254c 1 3 5.2u                           ; C device
M254d 1 2 3 0 NMOS L=0.13u W=88.6u AD=28.10p AS=119.17p PD=191.7u PS=246.8u ; M device
M254e 3 2 0 1 PMOS L=0.13u W=26.4u       ; M device
M254f 3 0 1 2 PMOS L=0.10u W=88.6u       ; M device
C254g 3 0 9.1u                           ; C device
R254h 1 2 58k                            ; R device
C254i 3 0 5.6u                           ; C device
R254j 2 3 528                            ; R device
C254k 1 2 17n                            ; C device
C254l 3 2 3n                             ; C device
C254m 2 3 8.9u                           ; C device
C254n 3 2 5.9u                           ; C device
M254o 0 1 2 3 NMOS L=0.70u W=7.6u        ; M device
C254p 3 2 392p                           ; C device
C254q 1 0 7.7u                           ; C device
M254r 1 2 0 3 NMOS L=0.10u W=34.1u       ; M device
C254s 2 3 69n                            ; C device
M254t 2 3 1 0 PMOS L=0.35u W=79.0u       ; M device
R254u 3 0 98                             ; R device
R254v 2 1 591                            ; R device
R254w 2 0 533                            ; R device
R254x 3 0 17k                            ; R device
M254y 2 1 3 0 PMOS L=0.25u W=9.2u AD=5.08p AS=9.92p PD=28.4u PS=34.7u ; M device
M254z 3 0 1 2 PMOS L=0.25u W=8.9u        ; M device
R255a 3 0 27k                            ; R device
R255b 0 2 28k                            ; R device
C255c 3 1 441p                           ; C device
R255d 0 1 15k                            ; R device
R255e 1 3 192                            ; R device
C255f 2 3 848p                           ; C device
C255g 1 2 14n                            ; C device
M255h 3 2 0 1 NMOS L=0.50u W=66.5u       ; M device
R255i 1 2 35k                            ; R device
C255j 3 1 39n                            ; C device
M255k 3 1 2 0 PMOS L=1.00u W=45.3u
+ AD=76.48p AS=83.23p PD=159.4u PS=93.3u ; M device
R255l 2 0 24k                            ; R device
C255m 2 3 4.2m                           ; C device
M255n 0 1 3 2 PMOS L=0.25u W=23.1u       ; M device
M255o 0 3 1 2 PMOS L=0.13u W=45.9u       ; M device
R255p 3 0 960                            ; R device
C255q 2 0 3.1m                           ; C device
M255r 2 1 3 0 NMOS L=0.50u W=84.3u       ; M device
C255s 2 1 5.7m                           ; C device
M255t 0 3 2 1 PMOS L=0.35u W=54.4u       ; M device
M255u 3 0 2 1 NMOS L=0.50u W=85.0u AD=28.74p AS=80.27p PD=183.0u PS=321.6u ; M device
M255v 0 3 2 1 PMOS L=0.50u W=82.3u       ; M device
C255w 1 2 51n                            ; C device
R255x 3 0 55k                            ; R device
M255y 2 0 1 3 PMOS L=1.00u W=57.1u       ; M device
M255z 3 1 2 0 PMOS L=0.18u W=63.2u       ; M device
M256a 0 3 2 1 PMOS L=0.50u W=25.7u       ; M device
R256b 2 0 37k                            ; R device
R256c 0 1 4.4M                           ; R device
R256d 2 0 97k                            ; R device
C256e 3 1 5.2u                           ; C device
C256f 0 3 425p                           ; C device
C256g 1 0 1.4m                           ; C device
M256h 3 2 1 0 PMOS L=0.13u W=95.2u AD=33.56p AS=156.48p PD=232.0u PS=261.5u ; M device
R256i 0 3 66k                            ; R device
M256j 1 3 2 0 NMOS L=0.35u W=67.0u       ; M device
R256k 3 0 2.4M                           ; R device
R256l 0 3 14k                            ; R device
C256m 3 0 9.3m                           ; C device
M256n 2 0 3 1 NMOS L=0.10u W=37.4u
+ AD=73.74p AS=62.85p PD=125.4u PS=84.6u ; M device
M256o 2 0 3 1 NMOS L=0.25u W=17.4u
+ AD=32.58p AS=16.19p PD=60.1u PS=52.5u ; M device
M256p 2 0 1 3 NMOS L=0.70u W=15.1u       ; M device
R256q 2 3 3.8M                           ; R device
C256r 3 2 865p                           ; C device
C256s 0 1 3.5m                           ; C device
C256t 1 3 468p                           ; C device
C256u 1 2 347p                           ; C device
C256v 0 3 24p                            ; C device
R256w 0 2 60k                            ; R device
M256x 3 0 2 1 PMOS L=0.25u W=48.8u
+ AD=54.12p AS=11.04p PD=193.6u PS=164.3u ; M device
R256y 1 2 75k                            ; R device
C256z 0 2 9.2m                           ; C device
R257a 3 0 6.6M                           ; R device
R257b 1 0 774                            ; R device
M257c 0 3 2 1 PMOS L=0.35u W=82.7u       ; M device
C257d 3 0 2.4m                           ; C device
M257e 1 3 0 2 PMOS L=0.35u W=32.0u       ; M device
C257f 3 2 5.7u                           ; C device
C257g 2 3 9.4m                           ; C device
M257h 2 0 3 1 NMOS L=0.18u W=63.3u
+ AD=31.58p AS=28.29p PD=208.2u PS=135.3u ; M device
C257i 3 2 3.9u                           ; C device
M257j 2 3 0 1 PMOS L=0.70u W=84.9u       ; M device
C257k 3 1 6.9u                           ; C device
C257l 1 0 5.7m                           ; C device
R257m 0 3 458                            ; R device
C257n 0 1 826p                           ; C device
R257o 2 1 2.3M                           ; R device
R257p 3 1 6.4M                           ; R device
C257q 3 2 0.4u                           ; C device
R257r 0 3 324                            ; R device
M257s 3 1 2 0 PMOS L=1.00u W=85.7u       ; M device
R257t 3 0 452                            ; R device
R257u 3 0 6.8M                           ; R device
C257v 0 3 9.6u                           ; C device
C257w 0 2 9.1u                           ; C device
M257x 1 0 2 3 NMOS L=0.25u W=66.7u
+ AD=131.27p AS=67.31p PD=184.4u PS=181.4u ; M device
M257y 0 2 1 3 NMOS L=0.70u W=36.8u       ; M device
C257z 2 3 760p                           ; C device
M258a 0 2 1 3 PMOS L=0.50u W=89.3u
+ AD=171.67p AS=38.94p PD=323.4u PS=353.3u ; M device
M258b 2 1 0 3 PMOS L=1.00u W=9.2u AD=2.08p AS=10.02p PD=19.1u PS=26.0u ; M device
R258c 2 1 27k                            ; R device
C258d 0 3 35n                            ; C device
M258e 1 3 0 2 PMOS L=0.13u W=24.9u       ; M device
M258f 3 1 0 2 NMOS L=0.10u W=0.5u
+ AD=0.63p AS=0.08p PD=1.6u PS=1.9u ; M device
R258g 2 0 5k                             ; R device
C258h 0 1 7.3u                           ; C device
C258i 0 3 37n                            ; C device
R258j 0 1 26                             ; R device
R258k 3 1 358                            ; R device
M258l 1 2 0 3 NMOS L=0.35u W=11.5u
+ AD=3.18p AS=21.76p PD=23.7u PS=42.3u ; M device
M258m 0 3 1 2 PMOS L=0.50u W=30.6u       ; M device
C258n 2 0 1.5u                           ; C device
C258o 3 0 17n                            ; C device
C258p 1 3 5.0m                           ; C device
C258q 3 2 97n                            ; C device
M258r 1 2 3 0 NMOS L=0.13u W=63.6u
+ AD=59.15p AS=18.24p PD=151.1u PS=171.0u ; M device
M258s 2 3 0 1 NMOS L=0.25u W=99.0u       ; M device
M258t 0 1 3 2 PMOS L=0.70u W=80.2u       ; M device
C258u 1 0 89p                            ; C device
M258v 3 0 1 2 PMOS L=0.13u W=33.7u       ; M device
C258w 1 3 8.6m                           ; C device
M258x 3 0 2 1 NMOS L=0.35u W=75.8u AD=138.77p AS=108.81p PD=256.2u PS=296.4u ; M device
C258y 3 1 43n                            ; C device
C258z 3 2 67n                            ; C device
R259a 2 3 358                            ; R device
C259b 1 2 7.7u                           ; C device
R259c 1 0 8.2M                           ; R device
R259d 3 1 552                            ; R device
M259e 2 1 0 3 NMOS L=0.50u W=5.9u
+ AD=3.84p AS=6.80p PD=18.8u PS=16.5u ; M device
M259f 0 2 1 3 PMOS L=0.50u W=34.0u
+ AD=54.05p AS=56.79p PD=124.6u PS=69.1u ; M device
C259g 2 0 147p                           ; C device
M259h 3 1 0 2 NMOS L=0.13u W=26.9u AD=23.78p AS=37.60p PD=71.3u PS=71.8u ; M device
R259i 0 1 785                            ; R device
M259j 0 2 3 1 PMOS L=0.18u W=54.3u       ; M device
R259k 2 0 3k                             ; R device
R259l 1 3 2.9M                           ; R device
C259m 3 2 44n                            ; C device
R259n 0 1 994                            ; R device
C259o 1 3 0.6u                           ; C device
R259p 2 3 76k                            ; R device
R259q 0 3 876                            ; R device
M259r 1 2 0 3 NMOS L=0.35u W=35.3u       ; M device
M259s 2 0 1 3 NMOS L=0.25u W=92.7u AD=38.17p AS=66.22p PD=259.1u PS=250.8u ; M device
R259t 2 0 283                            ; R device
R259u 2 1 66k                            ; R device
C259v 1 0 5.7u                           ; C device
C259w 1 0 85n                            ; C device
M259x 2 3 0 1 NMOS L=0.70u W=14.3u
+ AD=10.68p AS=21.21p PD=36.7u PS=45.6u ; M device
C259y 0 3 8.5m                           ; C device
R259z 0 2 5.3M                           ; R device
R260a 0 3 768                            ; R device
M260b 3 2 0 1 NMOS L=0.70u W=77.1u
+ AD=55.23p AS=44.57p PD=304.0u PS=303.8u ; M device
C260c 0 2 15n                            ; C device
C260d 0 2 2.8u                           ; C device
R260e 0 3 31k                            ; R device
M260f 0 3 1 2 NMOS L=0.25u W=14.0u AD=21.58p AS=3.75p PD=45.0u PS=49.8u ; M device
R260g 0 3 962                            ; R device
C260h 1 0 249p                           ; C device
C260i 1 0 1.3u                           ; C device
R260j 2 1 0.4M                           ; R device
R260k 1 3 45k                            ; R device
C260l 3 2 922p                           ; C device
M260m 2 1 3 0 PMOS L=0.70u W=18.1u       ; M device
R260n 2 0 3k                             ; R device
C260o 0 2 588p                           ; C device
R260p 0 2 856                            ; R device
R260q 2 3 1k                             ; R device
M260r 0 2 3 1 NMOS L=0.35u W=67.9u AD=69.97p AS=85.04p PD=246.2u PS=160.2u ; M device
R260s 2 3 21k                            ; R device
R260t 3 0 473                            ; R device
R260u 1 2 491                            ; R device
C260v 1 3 8.2m                           ; C device
R260w 2 1 3.2M                           ; R device
C260x 1 3 21n                            ; C device
R260y 2 1 68k                            ; R device
C260z 2 0 798p                           ; C device
M261a 1 2 3 0 NMOS L=0.35u W=60.8u       ; M device
R261b 2 1 99k                            ; R device
M261c 3 2 1 0 NMOS L=0.10u W=99.2u       ; M device
R261d 3 1 3.4M                           ; R device
M261e 0 2 1 3 PMOS L=0.25u W=1.3u        ; M device
R261f 1 0 5.9M                           ; R device
C261g 1 2 10.0m                          ; C device
M261h 2 1 0 3 NMOS L=0.25u W=5.0u AD=9.16p AS=7.18p PD=19.4u PS=19.9u ; M device
M261i 0 3 2 1 PMOS L=0.70u W=79.2u AD=36.19p AS=56.20p PD=272.4u PS=238.1u ; M device
C261j 2 3 418p                           ; C device
R261k 0 2 3.5M                           ; R device
M261l 2 0 1 3 NMOS L=0.70u W=84.8u       ; M device
C261m 0 3 195p                           ; C device
M261n 1 2 0 3 NMOS L=0.25u W=93.2u
+ AD=139.76p AS=11.73p PD=283.2u PS=257.0u ; M device
C261o 2 1 762p                           ; C device
M261p 1 2 3 0 PMOS L=0.50u W=94.2u       ; M device
R261q 3 2 57k                            ; R device
R261r 3 1 4.5M                           ; R device
C261s 1 3 6.8m                           ; C device
C261t 3 0 6.0m                           ; C device
M261u 0 2 3 1 PMOS L=0.13u W=75.1u AD=36.24p AS=128.43p PD=276.1u PS=286.2u ; M device
R261v 3 0 36k                            ; R device
M261w 3 0 1 2 PMOS L=0.70u W=73.3u AD=80.81p AS=110.50p PD=262.9u PS=192.9u ; M device
M261x 1 0 2 3 PMOS L=1.00u W=69.4u       ; M device
M261y 3 0 1 2 PMOS L=0.50u W=29.4u       ; M device
M261z 0 3 2 1 NMOS L=0.35u W=45.4u       ; M device
C262a 3 1 65n                            ; C device
C262b 1 3 299p                           ; C device
C262c 0 3 47n                            ; C device
C262d 3 2 7.2m                           ; C device
C262e 3 1 349p                           ; C device
M262f 3 2 1 0 NMOS L=1.00u W=91.0u
+ AD=148.47p AS=82.49p PD=326.1u PS=208.4u ; M device
C262g 2 1 1.2u                           ; C device
M262h 1 0 3 2 PMOS L=1.00u W=0.6u AD=0.72p AS=0.33p PD=2.4u PS=2.5u ; M device
M262i 0 3 2 1 PMOS L=0.50u W=42.3u AD=71.78p AS=32.00p PD=148.3u PS=90.0u ; M device
M262j 0 3 2 1 PMOS L=1.00u W=20.7u       ; M device
R262k 2 3 53k                            ; R device
R262l 0 3 4.8M                           ; R device
C262m 2 0 4.9u                           ; C device
M262n 1 0 3 2 NMOS L=1.00u W=10.6u
+ AD=10.96p AS=8.47p PD=34.8u PS=31.8u ; M device
C262o 0 1 6.4m                           ; C device
R262p 0 3 6.1M                           ; R device
M262q 3 1 2 0 NMOS L=0.18u W=52.7u
+ AD=8.86p AS=84.00p PD=195.7u PS=155.5u ; M device
M262r 3 2 1 0 PMOS L=0.70u W=9.9u AD=19.06p AS=11.03p PD=35.5u PS=26.7u ; M device
R262s 0 1 8.8M                           ; R device
R262t 3 0 68k                            ; R device
C262u 1 3 991p                           ; C device
C262v 3 2 1.8m                           ; C device
R262w 3 0 7.0M                           ; R device
R262x 0 2 57k                            ; R device
C262y 3 0 9.0m                           ; C device
R262z 1 0 7k                             ; R device
M263a 3 0 2 1 NMOS L=0.18u W=75.4u       ; M device
M263b 0 1 2 3 PMOS L=0.25u W=66.8u AD=54.95p AS=45.85p PD=213.1u PS=151.5u ; M device
C263c 2 0 7.2u                           ; C device
M263d 3 0 1 2 PMOS L=0.18u W=54.0u AD=93.01p AS=69.60p PD=161.4u PS=182.5u ; M device
M263e 2 3 1 0 NMOS L=0.13u W=13.3u
+ AD=6.91p AS=24.34p PD=52.5u PS=29.1u ; M device
C263f 2 0 59n                            ; C device
R263g 0 3 8.3M                           ; R device
M263h 1 0 2 3 NMOS L=0.10u W=12.9u
+ AD=6.99p AS=18.66p PD=48.8u PS=29.8u ; M device
M263i 1 2 3 0 NMOS L=0.70u W=22.8u       ; M device
R263j 1 3 7.6M                           ; R device
C263k 3 1 4.8u                           ; C device
M263l 2 0 1 3 PMOS L=0.35u W=30.1u
+ AD=28.95p AS=56.52p PD=98.6u PS=107.1u ; M device
C263m 2 1 40n                            ; C device
C263n 1 0 5.4m                           ; C device
R263o 0 2 994                            ; R device
M263p 0 1 2 3 PMOS L=1.00u W=36.8u       ; M device
M263q 3 2 1 0 NMOS L=0.70u W=30.0u
+ AD=48.35p AS=18.82p PD=118.0u PS=69.0u ; M device
M263r 1 0 2 3 PMOS L=0.25u W=48.2u
+ AD=46.03p AS=10.57p PD=134.8u PS=115.8u ; M device
C263s 2 3 61n                            ; C device
R263t 0 1 617                            ; R device
M263u 0 2 1 3 NMOS L=0.10u W=54.5u       ; M device
R263v 3 0 481                            ; R device
C263w 3 1 3.5m                           ; C device
R263x 1 0 125                            ; R device
R263y 3 2 3.2M                           ; R device
R263z 0 2 4.4M                           ; R device
C264a 3 2 2n                             ; C device
M264b 0 1 3 2 PMOS L=1.00u W=4.3u
+ AD=4.45p AS=4.48p PD=16.0u PS=16.3u ; M device
R264c 3 2 2.6M                           ; R device
C264d 1 0 59n                            ; C device
R264e 3 1 32                             ; R device
R264f 0 3 4.5M                           ; R device
C264g 2 0 899p                           ; C device
C264h 3 0 8.8m                           ; C device
R264i 2 3 885                            ; R device
C264j 0 3 434p                           ; C device
R264k 1 2 66k                            ; R device
R264l 1 2 416                            ; R device
M264m 3 1 0 2 NMOS L=0.70u W=54.5u
+ AD=65.20p AS=18.97p PD=161.1u PS=120.2u ; M device
C264n 3 1 6.2u                           ; C device
R264o 2 3 41k                            ; R device
C264p 3 2 4.3m                           ; C device
R264q 0 3 227                            ; R device
M264r 1 0 3 2 PMOS L=0.70u W=33.0u AD=17.42p AS=44.24p PD=117.6u PS=73.3u ; M device
R264s 0 1 236                            ; R device
C264t 0 2 459p                           ; C device
C264u 0 1 2.2u                           ; C device
R264v 0 3 93k                            ; R device
C264w 0 2 5.1u                           ; C device
M264x 0 2 1 3 NMOS L=0.13u W=15.4u       ; M device
M264y 2 0 1 3 NMOS L=0.25u W=71.6u       ; M device
C264z 1 0 852p                           ; C device
M265a 0 2 3 1 NMOS L=0.70u W=85.5u       ; M device
M265b 3 2 0 1 NMOS L=0.70u W=42.5u AD=5.10p AS=8.05p PD=124.2u PS=165.8u ; M device
C265c 3 2 510p                           ; C device
M265d 2 1 0 3 PMOS L=1.00u W=8.2u        ; M device
C265e 3 0 2.6u                           ; C device
C265f 2 3 4.8m                           ; C device
M265g 1 0 2 3 PMOS L=1.00u W=39.7u       ; M device
R265h 2 0 8.1M                           ; R device
M265i 0 2 1 3 PMOS L=0.25u W=56.0u AD=91.76p AS=42.15p PD=120.9u PS=163.3u ; M device
R265j 2 1 554                            ; R device
C265k 0 1 0.2u                           ; C device
R265l 3 0 10.0M                          ; R device
R265m 2 1 476                            ; R device
C265n 3 2 0.9u                           ; C device
C265o 1 0 30n                            ; C device
C265p 3 2 30n                            ; C device
M265q 3 2 0 1 PMOS L=1.00u W=94.5u AD=165.09p AS=80.45p PD=258.5u PS=318.1u ; M device
R265r 3 1 785                            ; R device
M265s 2 0 3 1 NMOS L=0.50u W=94.7u AD=182.45p AS=81.73p PD=296.8u PS=376.2u ; M device
R265t 0 1 1.5M                           ; R device
C265u 2 0 63n                            ; C device
C265v 2 0 3.7u                           ; C device
C265w 0 3 9.3u                           ; C device
C265x 2 3 669p                           ; C device
C265y 0 3 6.4u                           ; C device
C265z 1 2 0.2m                           ; C device
C266a 1 2 51n                            ; C device
R266b 2 1 87k                            ; R device
M266c 0 2 3 1 NMOS L=0.13u W=35.6u       ; M device
R266d 1 3 5.2M                           ; R device
R266e 1 2 53k                            ; R device
C266f 2 1 2.4m                           ; C device
M266g 2 1 0 3 NMOS L=0.10u W=36.9u       ; M device
R266h 0 3 28k                            ; R device
M266i 0 1 3 2 NMOS L=0.70u W=60.7u AD=81.48p AS=105.89p PD=141.4u PS=158.2u ; M device
C266j 1 0 45n                            ; C device
R266k 0 3 28k                            ; R device
R266l 1 0 26k                            ; R device
R266m 1 3 25k                            ; R device
C266n 2 3 4.2u                           ; C device
R266o 0 2 92k                            ; R device
R266p 2 3 1.4M                           ; R device
M266q 1 0 3 2 PMOS L=0.10u W=51.5u
+ AD=88.39p AS=86.02p PD=143.2u PS=198.6u ; M device
C266r 1 3 3.2m                           ; C device
M266s 1 3 2 0 NMOS L=0.10u W=17.0u
+ AD=14.36p AS=31.06p PD=51.5u PS=52.4u ; M device
R266t 0 3 390                            ; R device
C266u 2 0 544p                           ; C device
C266v 2 3 9.1m                           ; C device
M266w 2 0 1 3 NMOS L=0.13u W=48.9u       ; M device
C266x 0 3 7.5m                           ; C device
M266y 1 2 3 0 NMOS L=0.10u W=67.8u       ; M device
R266z 1 3 497                            ; R device
M267a 0 1 3 2 NMOS L=0.13u W=4.0u        ; M device
R267b 1 3 77k                            ; R device
M267c 0 2 1 3 NMOS L=0.50u W=17.9u
+ AD=28.23p AS=34.56p PD=67.9u PS=41.7u ; M device
M267d 0 2 3 1 PMOS L=0.35u W=63.0u AD=62.84p AS=44.17p PD=203.6u PS=239.1u ; M device
C267e 3 2 5.6m                           ; C device
R267f 2 0 1.1M                           ; R device
C267g 2 1 68n                            ; C device
M267h 0 1 3 2 NMOS L=0.18u W=60.5u       ; M device
M267i 0 3 1 2 PMOS L=1.00u W=92.6u AD=120.65p AS=129.65p PD=350.0u PS=214.9u ; M device
M267j 1 0 3 2 PMOS L=0.13u W=7.9u        ; M device
R267k 0 2 83k                            ; R device
M267l 0 2 1 3 NMOS L=0.25u W=17.2u
+ AD=14.52p AS=18.16p PD=52.0u PS=65.6u ; M device
M267m 0 2 1 3 NMOS L=1.00u W=77.6u       ; M device
M267n 0 3 2 1 PMOS L=0.25u W=92.2u       ; M device
C267o 2 0 1.5m                           ; C device
C267p 0 1 27n                            ; C device
R267q 2 1 202                            ; R device
M267r 1 2 3 0 NMOS L=0.10u W=41.7u AD=55.98p AS=34.08p PD=129.6u PS=101.6u ; M device
C267s 0 3 13n                            ; C device
R267t 3 2 15k                            ; R device
C267u 1 0 3.6m                           ; C device
C267v 3 2 2.7m                           ; C device
M267w 1 2 3 0 PMOS L=0.10u W=83.3u       ; M device
C267x 0 1 6.5m                           ; C device
M267y 1 3 0 2 PMOS L=0.25u W=98.2u
+ AD=128.94p AS=95.88p PD=216.7u PS=284.1u ; M device
M267z 0 1 3 2 PMOS L=0.18u W=97.1u       ; M device
C268a 3 1 705p                           ; C device
R268b 0 3 4.7M                           ; R device
M268c 3 1 2 0 NMOS L=0.70u W=51.3u       ; M device
R268d 1 3 86k                            ; R device
M268e 2 3 0 1 PMOS L=0.70u W=46.1u
+ AD=45.91p AS=7.13p PD=135.8u PS=134.6u ; M device
C268f 0 3 94n                            ; C device
R268g 3 1 469                            ; R device
M268h 0 1 2 3 NMOS L=0.25u W=46.7u       ; M device
R268i 0 1 2.3M                           ; R device
M268j 3 1 2 0 NMOS L=0.50u W=54.9u
+ AD=78.74p AS=101.02p PD=206.1u PS=172.1u ; M device
M268k 0 2 3 1 NMOS L=0.70u W=96.1u       ; M device
C268l 2 3 3.9m                           ; C device
C268m 2 3 5.9u                           ; C device
C268n 1 0 8.1u                           ; C device
M268o 2 3 1 0 NMOS L=1.00u W=84.1u       ; M device
C268p 3 0 679p                           ; C device
C268q 2 1 31n                            ; C device
C268r 0 3 6.6u                           ; C device
M268s 3 2 1 0 PMOS L=1.00u W=85.8u       ; M device
M268t 2 1 0 3 NMOS L=0.50u W=48.6u       ; M device
R268u 2 3 32k                            ; R device
R268v 0 2 598                            ; R device
C268w 0 2 21n                            ; C device
C268x 3 2 83n                            ; C device
M268y 3 1 0 2 NMOS L=0.35u W=75.8u AD=26.66p AS=109.05p PD=297.4u PS=268.7u ; M device
C268z 2 1 204p                           ; C device
M269a 0 1 2 3 PMOS L=0.10u W=83.3u
+ AD=60.98p AS=158.77p PD=207.7u PS=330.5u ; M device
C269b 1 3 260p                           ; C device
M269c 3 1 0 2 NMOS L=0.18u W=98.9u AD=43.23p AS=173.34p PD=202.3u PS=267.4u ; M device
C269d 3 2 31n                            ; C device
M269e 3 0 1 2 NMOS L=0.50u W=24.6u AD=48.56p AS=23.43p PD=53.8u PS=55.4u ; M device
M269f 0 3 1 2 PMOS L=0.13u W=38.7u       ; M device
C269g 3 0 11n                            ; C device
M269h 1 3 0 2 PMOS L=0.13u W=60.9u       ; M device
C269i 3 2 3.0u                           ; C device
M269j 0 1 3 2 NMOS L=0.18u W=36.3u       ; M device
M269k 2 3 1 0 PMOS L=1.00u W=29.3u
+ AD=12.07p AS=57.88p PD=82.0u PS=106.4u ; M device
M269l 2 3 0 1 PMOS L=0.25u W=56.9u AD=27.84p AS=11.77p PD=145.0u PS=224.1u ; M device
C269m 2 1 498p                           ; C device
M269n 3 1 0 2 PMOS L=0.10u W=39.0u       ; M device
M269o 3 0 2 1 NMOS L=0.35u W=14.0u       ; M device
M269p 0 3 1 2 NMOS L=1.00u W=61.2u       ; M device
C269q 1 3 8.9m                           ; C device
R269r 3 0 32k                            ; R device
R269s 1 0 81k                            ; R device
C269t 2 1 5.6u                           ; C device
R269u 1 2 2k                             ; R device
C269v 2 0 8.9u                           ; C device
M269w 2 1 3 0 NMOS L=0.35u W=10.3u AD=8.95p AS=11.13p PD=34.8u PS=33.1u ; M device
R269x 2 1 231                            ; R device
C269y 1 2 57n                            ; C device
M269z 3 2 1 0 NMOS L=0.35u W=39.1u       ; M device
R270a 1 2 94k                            ; R device
C270b 3 0 8.9u                           ; C device
R270c 0 3 0.6M                           ; R device
C270d 0 2 875p                           ; C device
R270e 0 3 21                             ; R device
M270f 0 1 3 2 PMOS L=0.50u W=4.0u AD=2.64p AS=5.32p PD=8.7u PS=9.7u ; M device
R270g 2 1 20k                            ; R device
C270h 3 1 72n                            ; C device
R270i 1 0 3.8M                           ; R device
M270j 1 2 3 0 PMOS L=1.00u W=61.6u AD=77.70p AS=78.16p PD=145.3u PS=245.5u ; M device
R270k 3 1 21k                            ; R device
C270l 1 3 440p                           ; C device
R270m 3 1 95k                            ; R device
C270n 2 3 2.6m                           ; C device
M270o 2 1 0 3 PMOS L=0.70u W=1.7u
+ AD=2.72p AS=2.18p PD=4.6u PS=5.4u ; M device
R270p 3 1 9.2M                           ; R device
C270q 1 2 179p                           ; C device
R270r 0 3 1.8M                           ; R device
C270s 0 2 9.7u                           ; C device
C270t 2 0 6.3u                           ; C device
M270u 1 2 0 3 NMOS L=0.10u W=89.6u       ; M device
C270v 2 1 2.3m                           ; C device
M270w 2 3 1 0 NMOS L=0.18u W=55.3u AD=85.43p AS=85.09p PD=174.6u PS=193.2u ; M device
C270x 3 0 34n                            ; C device
C270y 2 1 240p                           ; C device
C270z 3 0 21n                            ; C device
M271a 0 3 1 2 NMOS L=0.18u W=82.0u
+ AD=66.86p AS=163.23p PD=262.0u PS=287.4u ; M device
C271b 0 1 9.4m                           ; C device
M271c 2 3 1 0 PMOS L=0.10u W=70.7u       ; M device
M271d 2 0 1 3 NMOS L=0.25u W=8.0u        ; M device
M271e 0 3 1 2 NMOS L=0.10u W=64.4u       ; M device
M271f 2 3 1 0 NMOS L=0.25u W=90.0u
+ AD=124.29p AS=131.16p PD=237.5u PS=280.4u ; M device
C271g 1 2 567p                           ; C device
M271h 0 3 2 1 PMOS L=0.50u W=33.3u       ; M device
M271i 0 3 1 2 PMOS L=0.25u W=92.9u       ; M device
M271j 1 2 3 0 PMOS L=0.50u W=5.7u
+ AD=7.90p AS=9.50p PD=20.1u PS=20.1u ; M device
M271k 1 3 0 2 PMOS L=0.10u W=10.3u AD=13.61p AS=11.85p PD=32.1u PS=32.5u ; M device
R271l 0 3 89k                            ; R device
M271m 3 2 1 0 NMOS L=0.10u W=90.9u AD=33.30p AS=108.05p PD=262.3u PS=315.8u ; M device
R271n 3 1 92k                            ; R device
M271o 1 2 0 3 PMOS L=0.35u W=28.9u       ; M device
C271p 0 3 36n                            ; C device
C271q 1 3 704p                           ; C device
M271r 1 3 0 2 NMOS L=1.00u W=75.6u       ; M device
C271s 2 0 123p                           ; C device
R271t 1 3 7.7M                           ; R device
M271u 1 0 3 2 PMOS L=0.25u W=82.2u
+ AD=104.35p AS=112.44p PD=328.4u PS=183.0u ; M device
R271v 1 0 79k                            ; R device
R271w 3 0 6.1M                           ; R device
C271x 3 1 9n                             ; C device
R271y 2 0 8.1M                           ; R device
R271z 2 0 94                             ; R device
M272a 3 2 0 1 NMOS L=0.13u W=20.8u
+ AD=37.57p AS=2.80p PD=55.5u PS=47.5u ; M device
C272b 2 0 7.5m                           ; C device
R272c 3 0 7.4M                           ; R device
M272d 1 0 2 3 NMOS L=0.25u W=20.2u AD=27.64p AS=22.00p PD=55.8u PS=66.8u ; M device
M272e 3 1 2 0 NMOS L=0.50u W=59.6u       ; M device
M272f 2 0 3 1 PMOS L=0.18u W=67.0u
+ AD=25.77p AS=9.01p PD=207.5u PS=207.4u ; M device
M272g 0 2 3 1 PMOS L=0.70u W=10.9u AD=19.09p AS=2.70p PD=32.9u PS=22.2u ; M device
C272h 1 2 9.1m                           ; C device
M272i 0 1 3 2 NMOS L=0.50u W=80.5u       ; M device
M272j 3 2 0 1 NMOS L=0.50u W=86.0u       ; M device
M272k 3 2 1 0 PMOS L=0.18u W=49.2u AD=50.68p AS=17.41p PD=148.1u PS=142.0u ; M device
R272l 0 2 689                            ; R device
M272m 3 1 0 2 PMOS L=0.13u W=90.1u AD=21.07p AS=62.57p PD=230.7u PS=287.7u ; M device
C272n 3 1 868p                           ; C device
C272o 0 3 4.5u                           ; C device
C272p 2 1 4.4m                           ; C device
R272q 0 3 77k                            ; R device
R272r 3 1 29k                            ; R device
M272s 3 0 2 1 NMOS L=0.13u W=34.5u AD=35.63p AS=22.95p PD=70.0u PS=123.4u ; M device
M272t 0 3 1 2 NMOS L=0.70u W=75.3u
+ AD=63.99p AS=26.73p PD=214.6u PS=216.2u ; M device
C272u 0 2 0.8m                           ; C device
M272v 2 1 3 0 NMOS L=0.25u W=70.0u       ; M device
C272w 0 1 3.8u                           ; C device
C272x 3 2 3.5m                           ; C device
C272y 0 1 5.6m                           ; C device
C272z 0 1 7.3u                           ; C device
M273a 2 1 0 3 NMOS L=0.35u W=18.7u       ; M device
R273b 1 2 4.1M                           ; R device
C273c 2 0 96n                            ; C device
C273d 3 1 4.5m                           ; C device
R273e 1 3 874                            ; R device
R273f 0 1 13k                            ; R device
R273g 0 2 24k                            ; R device
M273h 1 2 3 0 NMOS L=0.13u W=25.4u       ; M device
R273i 2 0 3.4M                           ; R device
R273j 3 2 120                            ; R device
R273k 2 3 368                            ; R device
M273l 0 3 2 1 NMOS L=0.35u W=79.3u       ; M device
R273m 2 3 8.4M                           ; R device
M273n 1 0 3 2 PMOS L=0.50u W=42.2u       ; M device
C273o 1 2 2.1m                           ; C device
C273p 1 2 7.4u                           ; C device
R273q 0 3 87k                            ; R device
R273r 1 2 124                            ; R device
M273s 3 1 2 0 NMOS L=0.13u W=92.6u
+ AD=97.84p AS=76.87p PD=311.4u PS=218.6u ; M device
M273t 3 2 0 1 NMOS L=0.13u W=25.7u AD=10.57p AS=31.91p PD=74.6u PS=72.8u ; M device
M273u 2 0 1 3 NMOS L=0.70u W=7.9u        ; M device
M273v 2 1 3 0 NMOS L=0.70u W=0.9u        ; M device
R273w 3 0 479                            ; R device
C273x 3 2 1.6u                           ; C device
M273y 0 2 1 3 NMOS L=0.70u W=28.4u       ; M device
M273z 1 2 0 3 PMOS L=0.18u W=68.5u
+ AD=112.40p AS=120.75p PD=153.7u PS=227.6u ; M device
M274a 0 3 1 2 NMOS L=0.18u W=22.5u AD=18.60p AS=12.56p PD=82.5u PS=70.0u ; M device
M274b 2 3 1 0 NMOS L=0.70u W=81.1u AD=39.04p AS=85.31p PD=210.1u PS=292.2u ; M device
C274c 0 1 0.6m                           ; C device
R274d 3 0 19                             ; R device
R274e 3 0 475                            ; R device
M274f 3 1 0 2 PMOS L=0.70u W=24.4u       ; M device
R274g 3 2 49k                            ; R device
R274h 2 3 8.1M                           ; R device
C274i 3 2 3.2u                           ; C device
M274j 1 0 2 3 PMOS L=0.25u W=64.7u       ; M device
R274k 0 1 782                            ; R device
M274l 0 2 1 3 NMOS L=0.13u W=73.2u
+ AD=134.73p AS=128.57p PD=222.0u PS=176.7u ; M device
M274m 1 2 3 0 PMOS L=0.18u W=70.5u AD=55.94p AS=65.32p PD=247.3u PS=217.6u ; M device
M274n 3 0 1 2 NMOS L=1.00u W=94.8u       ; M device
R274o 0 2 609                            ; R device
C274p 2 0 397p                           ; C device
R274q 3 0 5.5M                           ; R device
C274r 3 2 470p                           ; C device
C274s 3 1 54n                            ; C device
M274t 2 0 1 3 NMOS L=0.13u W=91.2u
+ AD=96.69p AS=62.37p PD=340.7u PS=289.8u ; M device
C274u 2 3 2.8m                           ; C device
C274v 1 0 87n                            ; C device
R274w 3 0 357                            ; R device
C274x 0 1 7.4u                           ; C device
R274y 1 3 12k                            ; R device
R274z 0 2 96                             ; R device
R275a 3 2 25k                            ; R device
C275b 0 3 31n                            ; C device
M275c 2 1 3 0 NMOS L=0.50u W=23.7u       ; M device
R275d 0 2 7.0M                           ; R device
M275e 1 0 2 3 PMOS L=0.13u W=54.5u       ; M device
R275f 1 2 575                            ; R device
M275g 0 1 2 3 PMOS L=0.50u W=78.0u
+ AD=76.99p AS=16.36p PD=242.1u PS=307.0u ; M device
M275h 2 0 1 3 NMOS L=0.25u W=31.2u       ; M device
M275i 3 1 2 0 NMOS L=0.18u W=2.3u        ; M device
C275j 2 1 95n                            ; C device
M275k 0 1 3 2 PMOS L=0.70u W=36.5u AD=29.79p AS=11.74p PD=127.7u PS=74.2u ; M device
C275l 0 1 2.6m                           ; C device
R275m 3 1 69k                            ; R device
R275n 3 2 34k                            ; R device
C275o 2 1 0.4m                           ; C device
C275p 1 2 86n                            ; C device
M275q 3 0 1 2 PMOS L=1.00u W=76.2u       ; M device
M275r 0 1 2 3 NMOS L=0.10u W=82.0u       ; M device
M275s 2 3 1 0 PMOS L=0.25u W=17.9u       ; M device
M275t 0 2 1 3 NMOS L=0.35u W=42.9u       ; M device
R275u 2 1 50k                            ; R device
M275v 2 0 3 1 NMOS L=0.70u W=44.6u       ; M device
R275w 2 0 98k                            ; R device
R275x 1 2 19k                            ; R device
R275y 1 2 8.5M                           ; R device
R275z 3 1 550                            ; R device
M276a 2 1 0 3 NMOS L=0.35u W=88.1u       ; M device
M276b 0 1 2 3 NMOS L=0.35u W=9.9u
+ AD=17.03p AS=17.96p PD=25.4u PS=27.5u ; M device
R276c 3 1 8.4M                           ; R device
R276d 1 3 443                            ; R device
R276e 1 3 7.0M                           ; R device
M276f 1 3 0 2 PMOS L=0.25u W=82.6u
+ AD=36.91p AS=145.42p PD=165.6u PS=258.8u ; M device
C276g 1 2 50p                            ; C device
R276h 1 0 4.7M                           ; R device
C276i 0 3 7.9u                           ; C device
M276j 0 3 1 2 PMOS L=0.18u W=74.5u AD=101.44p AS=28.96p PD=173.2u PS=209.1u ; M device
C276k 0 3 592p                           ; C device
R276l 2 1 0.7M                           ; R device
M276m 0 1 3 2 PMOS L=0.13u W=66.6u
+ AD=47.01p AS=126.38p PD=147.6u PS=138.6u ; M device
M276n 3 1 2 0 PMOS L=0.35u W=38.2u
+ AD=59.75p AS=59.56p PD=89.8u PS=116.7u ; M device
R276o 0 2 33k                            ; R device
R276p 1 0 2.4M                           ; R device
M276q 1 3 0 2 PMOS L=1.00u W=15.0u AD=7.65p AS=9.51p PD=33.4u PS=50.5u ; M device
M276r 3 0 2 1 PMOS L=0.18u W=12.2u AD=19.56p AS=16.38p PD=25.4u PS=35.8u ; M device
M276s 1 2 0 3 NMOS L=0.13u W=40.3u       ; M device
C276t 2 1 2.0m                           ; C device
M276u 3 1 2 0 NMOS L=0.18u W=39.5u       ; M device
C276v 0 3 560p                           ; C device
M276w 2 1 3 0 PMOS L=0.35u W=60.7u       ; M device
C276x 2 1 420p                           ; C device
M276y 1 3 0 2 PMOS L=0.35u W=21.6u       ; M device
M276z 3 2 1 0 NMOS L=0.13u W=84.1u       ; M device
C277a 3 1 2.3m                           ; C device
R277b 1 3 7.1M                           ; R device
M277c 2 0 3 1 NMOS L=0.35u W=83.2u
+ AD=17.26p AS=45.24p PD=255.4u PS=317.4u ; M device
R277d 3 0 22k                            ; R device
C277e 3 0 79n                            ; C device
R277f 3 2 117                            ; R device
C277g 0 1 502p                           ; C device
M277h 2 3 0 1 PMOS L=0.25u W=15.7u
+ AD=2.07p AS=17.24p PD=54.5u PS=50.1u ; M device
R277i 1 3 2.1M                           ; R device
R277j 2 3 577                            ; R device
M277k 1 3 0 2 PMOS L=0.70u W=21.4u
+ AD=38.62p AS=33.25p PD=45.6u PS=55.9u ; M device
R277l 2 3 161                            ; R device
M277m 3 2 1 0 PMOS L=0.25u W=50.2u       ; M device
R277n 1 3 26                             ; R device
R277o 3 1 3.0M                           ; R device
R277p 3 2 283                            ; R device
R277q 2 1 1.6M                           ; R device
R277r 2 3 117                            ; R device
R277s 0 3 682                            ; R device
C277t 1 3 6.7u                           ; C device
M277u 0 3 1 2 PMOS L=0.50u W=52.9u AD=36.41p AS=37.17p PD=204.8u PS=168.8u ; M device
C277v 3 1 18n                            ; C device
C277w 3 1 988p                           ; C device
C277x 3 0 61n                            ; C device
R277y 1 0 5.6M                           ; R device
C277z 3 1 887p                           ; C device
C278a 3 1 50n                            ; C device
C278b 0 3 9.2m                           ; C device
R278c 3 1 9.2M                           ; R device
M278d 2 0 3 1 PMOS L=0.13u W=52.1u       ; M device
C278e 1 2 45n                            ; C device
M278f 2 1 3 0 PMOS L=0.25u W=50.1u       ; M device
M278g 3 0 2 1 NMOS L=0.50u W=74.5u       ; M device
R278h 2 0 84k                            ; R device
M278i 1 0 3 2 PMOS L=0.18u W=68.9u       ; M device
C278j 1 3 9.0m                           ; C device
R278k 2 0 64                             ; R device
M278l 0 2 1 3 PMOS L=0.70u W=3.5u AD=4.74p AS=4.34p PD=9.0u PS=9.4u ; M device
M278m 0 1 3 2 PMOS L=0.18u W=17.4u       ; M device
C278n 2 3 837p                           ; C device
R278o 1 3 7.0M                           ; R device
R278p 1 2 7.7M                           ; R device
C278q 2 3 0.1m                           ; C device
R278r 3 0 6k                             ; R device
M278s 0 3 2 1 PMOS L=1.00u W=98.1u
+ AD=195.44p AS=16.66p PD=200.2u PS=382.3u ; M device
M278t 0 3 1 2 PMOS L=0.70u W=55.6u       ; M device
R278u 3 1 334                            ; R device
R278v 2 0 9.3M                           ; R device
C278w 2 1 67n                            ; C device
C278x 0 3 824p                           ; C device
R278y 0 1 36k                            ; R device
R278z 2 3 731                            ; R device
C279a 1 3 147p                           ; C device
M279b 2 0 1 3 PMOS L=0.10u W=71.1u AD=11.24p AS=28.47p PD=191.9u PS=152.2u ; M device
M279c 3 2 1 0 NMOS L=0.13u W=21.6u       ; M device
R279d 0 1 12k                            ; R device
C279e 2 3 88n                            ; C device
R279f 1 0 30k                            ; R device
C279g 3 1 0.1m                           ; C device
M279h 1 2 3 0 NMOS L=0.25u W=4.0u
+ AD=3.25p AS=5.40p PD=13.9u PS=10.2u ; M device
M279i 1 0 2 3 NMOS L=0.18u W=46.4u
+ AD=56.52p AS=34.33p PD=141.4u PS=106.0u ; M device
R279j 3 2 9.7M                           ; R device
R279k 3 1 66k                            ; R device
R279l 1 3 503                            ; R device
R279m 0 3 595                            ; R device
C279n 3 2 29n                            ; C device
R279o 0 3 67k                            ; R device
C279p 1 2 190p                           ; C device
R279q 3 0 2.0M                           ; R device
R279r 1 0 6.2M                           ; R device
R279s 1 0 146                            ; R device
R279t 0 2 843                            ; R device
C279u 3 0 5.8u                           ; C device
R279v 3 0 8.1M                           ; R device
R279w 3 0 612                            ; R device
R279x 2 0 861                            ; R device
R279y 0 3 94k                            ; R device
R279z 3 2 3.5M                           ; R device
C280a 3 1 2.7m                           ; C device
R280b 0 3 19k                            ; R device
C280c 0 2 990p                           ; C device
R280d 0 2 268                            ; R device
C280e 3 2 88n                            ; C device
M280f 3 2 1 0 NMOS L=1.00u W=51.1u       ; M device
R280g 3 1 713                            ; R device
C280h 1 0 2.6u                           ; C device
R280i 2 1 3.6M                           ; R device
M280j 0 3 1 2 PMOS L=1.00u W=7.3u        ; M device
M280k 3 2 0 1 PMOS L=1.00u W=92.7u
+ AD=12.27p AS=87.24p PD=264.6u PS=195.7u ; M device
M280l 0 3 2 1 NMOS L=0.25u W=47.5u       ; M device
R280m 3 1 3.2M                           ; R device
R280n 1 3 5.2M                           ; R device
R280o 2 0 527                            ; R device
M280p 2 3 1 0 PMOS L=1.00u W=39.8u       ; M device
C280q 2 3 228p                           ; C device
R280r 0 1 8.0M                           ; R device
C280s 3 2 52n                            ; C device
R280t 3 1 716                            ; R device
M280u 0 3 2 1 NMOS L=0.18u W=75.3u
+ AD=16.58p AS=27.87p PD=222.1u PS=272.1u ; M device
M280v 0 1 2 3 PMOS L=0.18u W=73.4u AD=106.30p AS=27.95p PD=175.6u PS=191.2u ; M device
R280w 3 0 52k                            ; R device
C280x 2 1 959p                           ; C device
C280y 3 1 730p                           ; C device
C280z 2 3 2.8u                           ; C device
R281a 1 0 2.3M                           ; R device
C281b 1 0 0.7m                           ; C device
C281c 2 3 5.9m                           ; C device
M281d 3 1 2 0 NMOS L=0.50u W=9.0u        ; M device
M281e 0 3 1 2 NMOS L=1.00u W=25.3u AD=9.94p AS=10.92p PD=96.9u PS=55.0u ; M device
M281f 3 0 2 1 NMOS L=0.25u W=33.4u       ; M device
R281g 3 0 803                            ; R device
R281h 3 1 47k                            ; R device
R281i 2 3 989                            ; R device
C281j 0 3 8.0u                           ; C device
R281k 0 2 993                            ; R device
C281l 1 2 73n                            ; C device
R281m 0 3 7.6M                           ; R device
C281n 3 0 3.9u                           ; C device
C281o 3 2 8.9m                           ; C device
C281p 3 0 682p                           ; C device
C281q 0 1 1.4m                           ; C device
M281r 2 3 0 1 PMOS L=0.50u W=68.1u       ; M device
C281s 0 1 616p                           ; C device
M281t 1 3 0 2 PMOS L=0.70u W=82.2u       ; M device
R281u 1 3 20k                            ; R device
M281v 0 3 2 1 NMOS L=0.35u W=21.7u AD=24.43p AS=17.88p PD=70.4u PS=66.9u ; M device
R281w 3 2 85k                            ; R device
C281x 0 2 5.9m                           ; C device
M281y 3 2 1 0 NMOS L=0.18u W=36.1u       ; M device
R281z 1 0 64k                            ; R device
M282a 1 2 3 0 PMOS L=0.18u W=38.3u AD=72.11p AS=48.01p PD=132.3u PS=78.5u ; M device
M282b 3 1 0 2 PMOS L=0.35u W=61.3u       ; M device
C282c 0 1 39n                            ; C device
C282d 2 1 640p                           ; C device
R282e 3 0 4.3M                           ; R device
M282f 1 0 2 3 NMOS L=0.13u W=7.2u        ; M device
R282g 2 0 700                            ; R device
M282h 0 1 3 2 PMOS L=1.00u W=5.3u
+ AD=4.76p AS=5.18p PD=15.1u PS=20.1u ; M device
C282i 0 1 5.5m                           ; C device
R282j 3 1 230                            ; R device
C282k 1 2 8.8u                           ; C device
M282l 0 1 2 3 PMOS L=0.13u W=24.5u
+ AD=40.46p AS=4.44p PD=87.1u PS=87.1u ; M device
C282m 2 1 20p                            ; C device
C282n 1 2 806p                           ; C device
M282o 0 1 3 2 PMOS L=0.50u W=75.6u       ; M device
R282p 1 3 556                            ; R device
R282q 1 3 10k                            ; R device
C282r 3 2 6.4u                           ; C device
C282s 3 1 20n                            ; C device
C282t 2 0 9.1u                           ; C device
M282u 3 2 0 1 PMOS L=1.00u W=24.2u       ; M device
C282v 2 0 27n                            ; C device
M282w 3 0 1 2 NMOS L=0.70u W=97.9u AD=122.00p AS=142.06p PD=339.5u PS=318.8u ; M device
C282x 2 3 9.7u                           ; C device
R282y 1 2 2.4M                           ; R device
C282z 1 0 5.4u                           ; C device
C283a 3 0 8.9m                           ; C device
M283b 2 1 3 0 PMOS L=0.18u W=64.5u
+ AD=127.49p AS=56.49p PD=191.1u PS=180.6u ; M device
R283c 3 2 330                            ; R device
M283d 2 1 3 0 PMOS L=0.50u W=19.2u       ; M device
R283e 0 3 327                            ; R device
M283f 1 0 2 3 PMOS L=0.10u W=53.0u
+ AD=88.70p AS=38.22p PD=156.6u PS=124.6u ; M device
C283g 3 2 103p                           ; C device
M283h 0 1 2 3 NMOS L=0.25u W=89.6u       ; M device
C283i 3 1 42n                            ; C device
R283j 2 1 10k                            ; R device
C283k 2 3 2.9u                           ; C device
R283l 0 2 9.8M                           ; R device
M283m 1 3 2 0 PMOS L=0.18u W=98.6u AD=161.32p AS=26.57p PD=240.3u PS=324.2u ; M device
C283n 0 1 21n                            ; C device
M283o 1 2 3 0 NMOS L=0.25u W=78.5u AD=40.86p AS=99.48p PD=226.0u PS=194.4u ; M device
R283p 3 2 2.6M                           ; R device
R283q 3 2 93k                            ; R device
M283r 0 1 3 2 NMOS L=0.10u W=60.9u       ; M device
C283s 0 3 123p                           ; C device
M283t 0 2 1 3 NMOS L=0.18u W=57.3u       ; M device
C283u 3 1 63n                            ; C device
R283v 0 2 84                             ; R device
R283w 1 0 750                            ; R device
M283x 0 2 1 3 NMOS L=0.25u W=83.9u AD=42.05p AS=164.38p PD=196.4u PS=194.3u ; M device
R283y 2 0 6.0M                           ; R device
R283z 1 2 67k                            ; R device
C284a 0 2 138p                           ; C device
R284b 1 0 535                            ; R device
M284c 0 2 3 1 PMOS L=0.70u W=85.5u       ; M device
C284d 0 3 81n                            ; C device
R284e 0 2 4.7M                           ; R device
R284f 3 0 2.7M                           ; R device
C284g 3 0 5.0u                           ; C device
C284h 1 2 8.2m                           ; C device
M284i 2 0 1 3 NMOS L=0.35u W=60.5u       ; M device
R284j 3 2 82                             ; R device
C284k 2 3 4.8m                           ; C device
C284l 2 0 6.6m                           ; C device
R284m 3 2 5.4M                           ; R device
C284n 1 0 9.3u                           ; C device
R284o 0 2 751                            ; R device
R284p 2 0 73k                            ; R device
C284q 1 2 7.9u                           ; C device
R284r 0 1 56k                            ; R device
R284s 2 1 91k                            ; R device
M284t 3 2 1 0 PMOS L=0.13u W=50.8u
+ AD=60.24p AS=29.64p PD=191.2u PS=167.3u ; M device
M284u 1 3 2 0 PMOS L=0.50u W=23.7u
+ AD=13.05p AS=42.16p PD=59.2u PS=87.2u ; M device
R284v 1 3 1k                             ; R device
C284w 2 3 30n                            ; C device
R284x 3 2 77k                            ; R device
M284y 1 0 3 2 NMOS L=0.13u W=10.8u       ; M device
M284z 2 3 1 0 NMOS L=0.35u W=81.8u       ; M device
R285a 3 2 7.0M                           ; R device
R285b 2 0 46k                            ; R device
C285c 3 1 7.9m                           ; C device
R285d 1 3 67k                            ; R device
M285e 0 1 3 2 PMOS L=1.00u W=41.6u       ; M device
R285f 3 0 66k                            ; R device
M285g 2 0 3 1 PMOS L=0.70u W=64.1u AD=123.11p AS=45.80p PD=161.4u PS=153.8u ; M device
C285h 3 2 639p                           ; C device
R285i 3 2 2.4M                           ; R device
R285j 1 2 4.4M                           ; R device
R285k 2 3 386                            ; R device
R285l 0 2 305                            ; R device
C285m 2 1 3.2u                           ; C device
M285n 3 1 0 2 PMOS L=0.25u W=82.2u AD=19.19p AS=40.00p PD=240.6u PS=281.7u ; M device
R285o 2 3 782                            ; R device
C285p 3 1 5.5u                           ; C device
C285q 1 3 799p                           ; C device
C285r 3 2 0.8u                           ; C device
R285s 1 2 6.0M                           ; R device
R285t 1 2 77k                            ; R device
M285u 1 2 0 3 NMOS L=0.50u W=23.2u AD=35.72p AS=29.41p PD=51.0u PS=81.5u ; M device
R285v 1 3 6.3M                           ; R device
M285w 2 0 1 3 NMOS L=1.00u W=97.4u       ; M device
M285x 2 3 0 1 NMOS L=0.13u W=86.2u       ; M device
M285y 2 3 0 1 NMOS L=0.35u W=32.4u       ; M device
R285z 2 1 67k                            ; R device
M286a 3 2 1 0 PMOS L=0.13u W=46.8u       ; M device
C286b 2 1 1.8m                           ; C device
R286c 2 0 5.6M                           ; R device
R286d 3 2 4.4M                           ; R device
M286e 0 3 2 1 NMOS L=0.13u W=75.9u       ; M device
C286f 3 1 29n                            ; C device
R286g 1 3 20k                            ; R device
C286h 3 0 9.4m                           ; C device
R286i 2 0 65k                            ; R device
R286j 2 1 202                            ; R device
M286k 1 3 2 0 PMOS L=0.10u W=38.6u
+ AD=53.40p AS=29.38p PD=105.7u PS=122.5u ; M device
R286l 2 3 53k                            ; R device
C286m 1 2 528p                           ; C device
M286n 1 0 3 2 PMOS L=0.13u W=71.7u AD=25.45p AS=108.45p PD=178.6u PS=252.0u ; M device
R286o 3 1 83k                            ; R device
C286p 0 3 533p                           ; C device
R286q 3 1 60                             ; R device
R286r 2 3 304                            ; R device
C286s 2 0 8.9m                           ; C device
C286t 0 3 15n                            ; C device
C286u 3 0 5.0u                           ; C device
R286v 2 0 256                            ; R device
M286w 2 0 3 1 NMOS L=0.25u W=88.1u AD=97.63p AS=171.80p PD=247.6u PS=264.4u ; M device
M286x 3 0 1 2 NMOS L=0.70u W=88.1u
+ AD=130.56p AS=74.08p PD=330.1u PS=313.2u ; M device
R286y 3 0 6.2M                           ; R device
M286z 1 3 0 2 PMOS L=0.35u W=73.2u       ; M device
M287a 3 0 1 2 NMOS L=0.25u W=70.4u       ; M device
R287b 1 3 3.4M                           ; R device
M287c 0 2 1 3 NMOS L=1.00u W=89.4u AD=90.26p AS=110.43p PD=216.1u PS=274.6u ; M device
M287d 2 1 3 0 NMOS L=0.18u W=33.1u
+ AD=55.90p AS=38.82p PD=99.4u PS=127.9u ; M device
C287e 1 0 61n                            ; C device
M287f 3 1 2 0 PMOS L=0.10u W=71.8u
+ AD=112.17p AS=72.84p PD=266.8u PS=251.1u ; M device
C287g 2 3 79n                            ; C device
C287h 2 0 3.6u                           ; C device
R287i 2 1 0.4M                           ; R device
C287j 1 3 2.4m                           ; C device
M287k 2 1 0 3 NMOS L=0.25u W=53.9u
+ AD=29.54p AS=9.73p PD=175.5u PS=166.7u ; M device
R287l 1 0 21k                            ; R device
M287m 3 1 2 0 PMOS L=0.70u W=34.2u
+ AD=10.25p AS=9.86p PD=74.9u PS=109.8u ; M device
C287n 0 2 725p                           ; C device
M287o 3 2 1 0 PMOS L=0.50u W=48.3u
+ AD=12.68p AS=89.36p PD=105.4u PS=147.2u ; M device
C287p 1 0 1.5u                           ; C device
M287q 2 1 3 0 PMOS L=1.00u W=48.6u       ; M device
M287r 3 0 2 1 NMOS L=0.10u W=80.7u       ; M device
M287s 2 3 0 1 NMOS L=0.13u W=38.6u
+ AD=50.34p AS=62.43p PD=113.7u PS=88.5u ; M device
M287t 0 2 3 1 PMOS L=0.10u W=27.0u
+ AD=53.83p AS=12.58p PD=79.2u PS=60.6u ; M device
M287u 3 0 1 2 PMOS L=0.13u W=65.1u       ; M device
R287v 0 1 41k                            ; R device
C287w 2 3 0.3u                           ; C device
R287x 1 3 7.3M                           ; R device
M287y 3 1 0 2 NMOS L=0.50u W=86.7u       ; M device
R287z 2 1 88k                            ; R device
R288a 2 3 5.5M                           ; R device
R288b 2 3 701                            ; R device
R288c 1 3 0.8M                           ; R device
R288d 0 1 36k                            ; R device
C288e 3 1 71n                            ; C device
M288f 1 0 3 2 NMOS L=1.00u W=14.7u       ; M device
M288g 3 0 2 1 PMOS L=0.13u W=63.3u       ; M device
M288h 1 2 0 3 PMOS L=0.70u W=60.4u AD=57.73p AS=56.01p PD=208.7u PS=231.2u ; M device
R288i 2 0 454                            ; R device
M288j 1 0 2 3 PMOS L=0.70u W=29.3u       ; M device
R288k 1 2 320                            ; R device
C288l 2 1 791p                           ; C device
M288m 1 3 2 0 NMOS L=0.13u W=44.0u AD=26.91p AS=74.22p PD=113.6u PS=129.1u ; M device
R288n 2 0 9.0M                           ; R device
C288o 3 1 7.2u                           ; C device
C288p 3 1 3n                             ; C device
M288q 0 1 3 2 NMOS L=0.13u W=60.5u       ; M device
R288r 2 3 306                            ; R device
R288s 2 3 51k                            ; R device
R288t 0 1 691                            ; R device
C288u 3 0 22n                            ; C device
M288v 3 0 1 2 PMOS L=0.13u W=88.6u
+ AD=134.94p AS=62.58p PD=349.1u PS=243.2u ; M device
M288w 1 0 3 2 NMOS L=1.00u W=95.9u
+ AD=120.55p AS=121.92p PD=288.8u PS=367.4u ; M device
C288x 1 2 5.0m                           ; C device
C288y 3 1 104p                           ; C device
R288z 3 2 80k                            ; R device
R289a 0 3 596                            ; R device
M289b 1 0 2 3 PMOS L=0.25u W=70.8u       ; M device
C289c 0 2 7.6u                           ; C device
C289d 2 1 9.9m                           ; C device
R289e 2 0 0.9M                           ; R device
C289f 0 1 2.3u                           ; C device
C289g 0 2 6n                             ; C device
M289h 2 0 1 3 NMOS L=0.50u W=81.5u       ; M device
M289i 1 3 2 0 NMOS L=0.13u W=15.7u AD=30.10p AS=26.07p PD=34.2u PS=53.0u ; M device
M289j 0 2 3 1 PMOS L=0.35u W=50.8u       ; M device
C289k 1 0 1.7m                           ; C device
C289l 3 0 3.7m                           ; C device
M289m 0 1 2 3 NMOS L=0.70u W=4.1u        ; M device
M289n 1 2 3 0 PMOS L=1.00u W=68.1u AD=82.77p AS=29.42p PD=255.3u PS=216.0u ; M device
C289o 1 2 1.2u                           ; C device
C289p 3 1 2.9m                           ; C device
R289q 1 2 739                            ; R device
C289r 3 1 39n                            ; C device
C289s 2 0 221p                           ; C device
M289t 0 3 2 1 PMOS L=0.18u W=74.4u
+ AD=78.53p AS=31.67p PD=192.7u PS=162.9u ; M device
R289u 1 0 38k                            ; R device
C289v 2 1 0.5u                           ; C device
M289w 3 1 2 0 PMOS L=0.18u W=77.3u       ; M device
C289x 2 0 1.1u                           ; C device
C289y 0 3 281p                           ; C device
R289z 1 3 31k                            ; R device
M290a 1 0 3 2 NMOS L=0.35u W=51.9u AD=85.43p AS=98.45p PD=149.3u PS=151.7u ; M device
R290b 1 3 317                            ; R device
C290c 0 2 1.1u                           ; C device
M290d 2 0 1 3 PMOS L=1.00u W=92.3u AD=69.45p AS=163.15p PD=329.7u PS=358.9u ; M device
C290e 3 1 7.9m                           ; C device
C290f 2 3 72n                            ; C device
C290g 2 0 260p                           ; C device
M290h 3 1 0 2 NMOS L=0.70u W=46.8u AD=48.90p AS=56.42p PD=163.0u PS=123.6u ; M device
M290i 3 0 1 2 PMOS L=0.18u W=1.5u        ; M device
R290j 1 3 86k                            ; R device
C290k 1 3 10p                            ; C device
M290l 3 2 1 0 PMOS L=0.35u W=98.1u       ; M device
R290m 2 3 22k                            ; R device
M290n 3 0 1 2 NMOS L=1.00u W=60.8u       ; M device
C290o 2 1 68p                            ; C device
M290p 3 1 2 0 PMOS L=0.13u W=29.7u       ; M device
C290q 0 1 2.4m                           ; C device
C290r 3 2 53n                            ; C device
R290s 2 3 166                            ; R device
M290t 1 2 3 0 PMOS L=0.50u W=73.1u AD=85.85p AS=65.33p PD=202.3u PS=161.9u ; M device
M290u 2 0 1 3 NMOS L=1.00u W=98.0u AD=98.94p AS=12.90p PD=316.0u PS=368.4u ; M device
M290v 1 3 2 0 NMOS L=0.50u W=62.7u       ; M device
M290w 1 3 0 2 NMOS L=0.50u W=46.3u AD=71.23p AS=25.52p PD=142.9u PS=129.7u ; M device
M290x 1 2 0 3 PMOS L=0.25u W=84.9u       ; M device
C290y 3 2 1.4u                           ; C device
R290z 1 0 2.4M                           ; R device
R291a 2 1 103                            ; R device
R291b 0 1 432                            ; R device
C291c 3 0 41n                            ; C device
M291d 1 2 3 0 PMOS L=0.35u W=54.7u AD=108.25p AS=61.30p PD=176.4u PS=162.4u ; M device
C291e 2 0 502p                           ; C device
C291f 1 0 9.2m                           ; C device
C291g 0 3 9.7u                           ; C device
M291h 2 1 3 0 PMOS L=0.10u W=19.4u
+ AD=3.18p AS=33.95p PD=74.2u PS=59.2u ; M device
R291i 2 3 478                            ; R device
C291j 0 2 456p                           ; C device
M291k 2 3 1 0 NMOS L=0.10u W=29.3u       ; M device
M291l 2 3 0 1 NMOS L=1.00u W=65.5u       ; M device
C291m 3 2 8.0u                           ; C device
M291n 1 2 3 0 PMOS L=0.70u W=32.4u       ; M device
C291o 1 0 5.7m                           ; C device
C291p 3 2 633p                           ; C device
M291q 1 2 0 3 PMOS L=0.18u W=21.9u       ; M device
R291r 1 2 44k                            ; R device
C291s 3 2 2.4u                           ; C device
R291t 1 3 433                            ; R device
C291u 0 2 4n                             ; C device
C291v 3 0 51n                            ; C device
C291w 1 3 46n                            ; C device
M291x 3 2 1 0 NMOS L=0.18u W=3.0u AD=5.17p AS=4.71p PD=7.4u PS=10.2u ; M device
M291y 1 3 2 0 NMOS L=0.70u W=31.8u AD=40.17p AS=44.62p PD=102.9u PS=112.5u ; M device
M291z 3 1 2 0 PMOS L=0.13u W=84.1u AD=113.06p AS=86.80p PD=185.9u PS=283.2u ; M device
M292a 0 3 2 1 NMOS L=0.18u W=73.5u       ; M device
C292b 2 3 1.9m                           ; C device
M292c 0 1 3 2 NMOS L=0.70u W=9.4u
+ AD=5.61p AS=15.92p PD=25.4u PS=32.9u ; M device
C292d 1 2 81n                            ; C device
C292e 2 0 6n                             ; C device
C292f 0 2 99n                            ; C device
C292g 0 1 69n                            ; C device
M292h 1 3 2 0 PMOS L=0.25u W=99.4u       ; M device
C292i 3 2 2.2u                           ; C device
C292j 1 0 508p                           ; C device
C292k 2 3 3.4m                           ; C device
M292l 2 1 3 0 NMOS L=0.50u W=86.3u AD=113.91p AS=128.35p PD=233.7u PS=303.4u ; M device
R292m 0 1 143                            ; R device
C292n 0 1 7.5u                           ; C device
R292o 2 0 6.0M                           ; R device
M292p 2 0 3 1 NMOS L=0.50u W=89.5u       ; M device
R292q 2 0 94k                            ; R device
R292r 3 0 77                             ; R device
M292s 3 1 2 0 NMOS L=0.10u W=93.8u AD=36.29p AS=64.31p PD=224.4u PS=278.6u ; M device
R292t 3 0 1.5M                           ; R device
M292u 0 3 2 1 NMOS L=0.25u W=8.4u        ; M device
M292v 3 0 1 2 NMOS L=0.10u W=66.6u AD=53.03p AS=24.04p PD=160.9u PS=198.2u ; M device
C292w 2 0 7.8m                           ; C device
R292x 1 3 6.2M                           ; R device
R292y 0 1 57k                            ; R device
C292z 3 1 3.8u                           ; C device
C293a 1 3 199p                           ; C device
M293b 1 3 2 0 PMOS L=0.35u W=75.2u       ; M device
C293c 0 2 29n                            ; C device
M293d 3 1 0 2 PMOS L=0.35u W=46.0u
+ AD=66.61p AS=5.96p PD=109.0u PS=164.1u ; M device
C293e 0 1 24n                            ; C device
M293f 0 3 2 1 NMOS L=0.10u W=80.5u AD=133.21p AS=70.97p PD=206.1u PS=271.4u ; M device
M293g 2 1 0 3 NMOS L=0.70u W=92.6u       ; M device
M293h 0 3 2 1 PMOS L=0.35u W=95.1u       ; M device
M293i 1 3 2 0 PMOS L=0.10u W=66.2u AD=36.26p AS=131.98p PD=250.3u PS=217.9u ; M device
C293j 2 1 87p                            ; C device
C293k 0 1 625p                           ; C device
M293l 1 3 0 2 NMOS L=0.70u W=57.9u
+ AD=6.97p AS=68.62p PD=154.8u PS=129.8u ; M device
C293m 2 1 804p                           ; C device
R293n 1 0 5.6M                           ; R device
M293o 3 2 0 1 NMOS L=0.50u W=45.2u       ; M device
C293p 2 0 5.5m                           ; C device
R293q 1 2 92k                            ; R device
R293r 1 2 66k                            ; R device
M293s 0 2 1 3 NMOS L=0.50u W=61.6u       ; M device
C293t 2 3 17n                            ; C device
R293u 3 1 60k                            ; R device
R293v 1 3 902                            ; R device
R293w 0 1 53k                            ; R device
C293x 1 3 2.8u                           ; C device
R293y 0 2 713                            ; R device
M293z 3 2 1 0 NMOS L=0.25u W=41.1u       ; M device
M294a 0 3 2 1 PMOS L=0.13u W=60.2u       ; M device
C294b 3 1 2.5u                           ; C device
C294c 0 1 963p                           ; C device
R294d 3 2 659                            ; R device
R294e 3 1 958                            ; R device
C294f 0 3 6.4m                           ; C device
C294g 1 3 8.4u                           ; C device
C294h 0 3 97p                            ; C device
C294i 0 2 54n                            ; C device
R294j 0 1 2.5M                           ; R device
R294k 2 1 49k                            ; R device
R294l 3 2 7.3M                           ; R device
R294m 2 3 29k                            ; R device
C294n 2 3 378p                           ; C device
C294o 2 0 5.9u                           ; C device
M294p 2 0 1 3 PMOS L=0.18u W=92.8u       ; M device
C294q 0 1 111p                           ; C device
R294r 0 3 13                             ; R device
M294s 1 3 2 0 NMOS L=0.25u W=22.9u AD=32.37p AS=40.45p PD=86.4u PS=46.0u ; M device
C294t 3 1 986p                           ; C device
R294u 1 3 93k                            ; R device
R294v 0 2 527                            ; R device
R294w 0 1 3k                             ; R device
C294x 2 1 875p                           ; C device
M294y 3 2 0 1 PMOS L=0.50u W=57.4u       ; M device
R294z 0 3 751                            ; R device
C295a 2 1 1.4u                           ; C device
M295b 2 0 1 3 NMOS L=1.00u W=12.1u       ; M device
C295c 0 2 88p                            ; C device
R295d 3 1 2.1M                           ; R device
R295e 2 1 1.2M                           ; R device
C295f 0 3 1.2m                           ; C device
R295g 3 0 34k                            ; R device
R295h 0 2 891                            ; R device
M295i 3 1 0 2 NMOS L=0.35u W=42.6u       ; M device
R295j 2 3 97k                            ; R device
M295k 1 3 0 2 PMOS L=0.10u W=67.6u AD=90.89p AS=93.16p PD=236.8u PS=260.7u ; M device
R295l 2 3 39k                            ; R device
R295m 1 3 41k                            ; R device
R295n 0 1 3.5M                           ; R device
R295o 0 1 7                              ; R device
M295p 0 2 1 3 NMOS L=0.10u W=32.6u AD=58.93p AS=12.59p PD=125.8u PS=80.8u ; M device
C295q 2 1 10n                            ; C device
C295r 1 0 8.7u                           ; C device
R295s 2 3 55k                            ; R device
C295t 0 1 41p                            ; C device
M295u 0 3 2 1 PMOS L=1.00u W=8.8u AD=15.37p AS=15.85p PD=27.3u PS=28.8u ; M device
M295v 2 3 0 1 PMOS L=0.10u W=53.8u       ; M device
C295w 0 3 6.4m                           ; C device
C295x 3 1 8.2m                           ; C device
M295y 0 1 2 3 PMOS L=1.00u W=26.3u       ; M device
R295z 3 0 27k                            ; R device
M296a 3 0 2 1 NMOS L=1.00u W=12.7u
+ AD=4.73p AS=8.74p PD=48.0u PS=33.3u ; M device
R296b 3 1 244                            ; R device
M296c 2 3 1 0 NMOS L=0.35u W=35.5u AD=5.05p AS=10.72p PD=105.8u PS=107.4u ; M device
C296d 2 1 6.8u                           ; C device
M296e 1 2 0 3 NMOS L=0.25u W=37.3u       ; M device
M296f 1 2 0 3 NMOS L=0.10u W=96.0u
+ AD=176.14p AS=76.84p PD=208.0u PS=346.8u ; M device
R296g 0 3 4k                             ; R device
M296h 1 2 3 0 NMOS L=0.70u W=38.3u       ; M device
M296i 2 3 1 0 NMOS L=0.50u W=48.7u       ; M device
C296j 1 0 59n                            ; C device
M296k 3 2 1 0 NMOS L=0.70u W=3.2u        ; M device
R296l 3 0 8.1M                           ; R device
M296m 2 3 1 0 NMOS L=0.25u W=58.3u       ; M device
C296n 0 3 786p                           ; C device
M296o 1 2 3 0 PMOS L=0.25u W=30.1u       ; M device
R296p 2 0 670                            ; R device
R296q 0 3 206                            ; R device
M296r 2 0 3 1 NMOS L=0.35u W=23.7u       ; M device
R296s 1 2 2.0M                           ; R device
M296t 0 2 1 3 PMOS L=0.10u W=67.9u       ; M device
R296u 3 2 720                            ; R device
R296v 2 0 3.3M                           ; R device
C296w 1 0 50p                            ; C device
M296x 2 3 0 1 NMOS L=0.50u W=72.6u       ; M device
R296y 1 3 286                            ; R device
R296z 1 3 5.0M                           ; R device
M297a 2 0 3 1 NMOS L=1.00u W=61.2u       ; M device
C297b 0 2 65n                            ; C device
C297c 3 0 6n                             ; C device
R297d 0 1 5.3M                           ; R device
M297e 1 2 0 3 NMOS L=1.00u W=14.4u
+ AD=7.18p AS=18.99p PD=31.0u PS=39.4u ; M device
C297f 1 2 0.7m                           ; C device
R297g 0 3 6.6M                           ; R device
R297h 3 1 3.0M                           ; R device
M297i 1 2 0 3 PMOS L=0.25u W=29.7u AD=19.75p AS=50.64p PD=64.5u PS=64.2u ; M device
R297j 1 2 9.2M                           ; R device
C297k 3 2 316p                           ; C device
C297l 3 1 3.0u                           ; C device
R297m 0 1 336                            ; R device
R297n 1 0 1.0M                           ; R device
C297o 1 2 218p                           ; C device
R297p 3 2 8.7M                           ; R device
M297q 2 3 1 0 NMOS L=0.13u W=28.6u
+ AD=23.31p AS=9.58p PD=96.4u PS=91.8u ; M device
R297r 2 1 6.8M                           ; R device
R297s 3 0 6.0M                           ; R device
M297t 1 3 0 2 PMOS L=1.00u W=2.5u AD=0.41p AS=4.77p PD=6.6u PS=8.2u ; M device
M297u 3 0 1 2 PMOS L=0.35u W=12.5u
+ AD=3.71p AS=2.91p PD=40.4u PS=39.1u ; M device
C297v 0 2 5.3m                           ; C device
R297w 0 3 9.2M                           ; R device
C297x 2 3 249p                           ; C device
M297y 3 0 1 2 NMOS L=0.18u W=79.3u AD=90.79p AS=73.36p PD=234.2u PS=174.7u ; M device
R297z 1 3 99                             ; R device
R298a 0 3 285                            ; R device
M298b 0 1 3 2 NMOS L=1.00u W=7.3u
+ AD=2.46p AS=6.13p PD=25.9u PS=26.4u ; M device
R298c 3 1 5.4M                           ; R device
R298d 1 0 3.6M                           ; R device
M298e 2 0 3 1 PMOS L=0.13u W=82.7u AD=83.24p AS=32.31p PD=195.4u PS=295.6u ; M device
C298f 3 0 0.9u                           ; C device
C298g 1 2 8.7u                           ; C device
R298h 0 2 704                            ; R device
M298i 1 0 3 2 PMOS L=0.18u W=44.6u       ; M device
M298j 0 3 1 2 NMOS L=0.18u W=96.6u AD=83.38p AS=139.06p PD=281.6u PS=337.4u ; M device
R298k 0 2 83k                            ; R device
M298l 2 1 0 3 NMOS L=0.18u W=51.1u       ; M device
C298m 1 2 429p                           ; C device
M298n 2 0 3 1 NMOS L=0.10u W=65.2u       ; M device
C298o 2 0 90n                            ; C device
M298p 0 3 2 1 PMOS L=0.35u W=28.8u
+ AD=43.73p AS=38.32p PD=98.7u PS=65.2u ; M device
R298q 2 3 82k                            ; R device
R298r 0 3 116                            ; R device
C298s 0 1 3.3m                           ; C device
R298t 0 3 856                            ; R device
M298u 2 1 0 3 PMOS L=0.10u W=2.5u        ; M device
C298v 2 1 3n                             ; C device
R298w 1 0 1.6M                           ; R device
R298x 3 0 27k                            ; R device
R298y 2 3 11k                            ; R device
R298z 3 0 57                             ; R device
M299a 3 1 0 2 PMOS L=0.10u W=97.9u
+ AD=141.80p AS=131.51p PD=267.7u PS=299.0u ; M device
M299b 0 2 3 1 NMOS L=1.00u W=8.4u        ; M device
C299c 0 3 1n                             ; C device
R299d 3 0 4.2M                           ; R device
M299e 1 2 0 3 NMOS L=0.50u W=2.7u        ; M device
R299f 2 1 6.5M                           ; R device
C299g 2 0 7.9u                           ; C device
C299h 1 2 295p                           ; C device
R299i 2 3 81k                            ; R device
M299j 3 2 0 1 PMOS L=0.18u W=14.6u
+ AD=21.26p AS=3.57p PD=45.9u PS=30.2u ; M device
R299k 2 1 59k                            ; R device
M299l 2 0 3 1 PMOS L=0.10u W=81.2u AD=103.21p AS=48.15p PD=318.2u PS=317.1u ; M device
M299m 3 2 0 1 PMOS L=0.25u W=11.5u       ; M device
M299n 1 2 0 3 PMOS L=1.00u W=83.8u AD=32.61p AS=159.13p PD=286.7u PS=254.1u ; M device
C299o 3 0 681p                           ; C device
M299p 3 1 2 0 NMOS L=0.70u W=25.9u
+ AD=37.54p AS=44.83p PD=90.3u PS=52.5u ; M device
M299q 3 2 0 1 PMOS L=0.70u W=94.8u       ; M device
R299r 3 1 80k                            ; R device
C299s 3 2 7.9m                           ; C device
R299t 3 2 4.6M                           ; R device
M299u 1 2 0 3 PMOS L=1.00u W=34.7u
+ AD=30.04p AS=68.93p PD=134.8u PS=123.4u ; M device
R299v 3 1 60k                            ; R device
C299w 3 0 7.2m                           ; C device
R299x 2 3 62k                            ; R device
M299y 1 3 0 2 NMOS L=0.18u W=83.8u       ; M device
C299z 1 3 3.6u                           ; C device
C300a 2 1 6.5u                           ; C device
C300b 0 3 89n                            ; C device
R300c 0 1 7.7M                           ; R device
M300d 0 1 3 2 PMOS L=0.18u W=85.8u       ; M device
M300e 0 3 2 1 PMOS L=1.00u W=29.8u
+ AD=22.96p AS=36.74p PD=69.1u PS=107.6u ; M device
M300f 1 2 3 0 PMOS L=0.13u W=63.4u       ; M device
M300g 2 1 3 0 PMOS L=0.10u W=12.0u AD=19.45p AS=3.16p PD=33.0u PS=32.9u ; M device
R300h 0 1 12k                            ; R device
R300i 2 3 2.6M                           ; R device
M300j 1 2 0 3 PMOS L=0.10u W=13.5u       ; M device
R300k 1 3 341                            ; R device
R300l 3 0 113                            ; R device
R300m 0 1 93k                            ; R device
M300n 0 3 2 1 PMOS L=0.25u W=91.4u       ; M device
C300o 0 1 3.5u                           ; C device
C300p 0 1 0.1m                           ; C device
C300q 0 3 984p                           ; C device
R300r 1 2 37k                            ; R device
R300s 0 2 718                            ; R device
M300t 3 0 1 2 NMOS L=0.18u W=88.7u AD=43.98p AS=12.28p PD=232.7u PS=348.3u ; M device
R300u 1 3 92k                            ; R device
C300v 0 1 4.5m                           ; C device
C300w 2 3 7n                             ; C device
R300x 3 1 567                            ; R device
M300y 1 2 3 0 NMOS L=0.35u W=64.8u       ; M device
R300z 3 2 32k                            ; R device
C301a 1 2 0.6u                           ; C device
R301b 1 3 0.8M                           ; R device
M301c 0 3 2 1 NMOS L=0.18u W=19.9u       ; M device
M301d 2 3 1 0 NMOS L=1.00u W=57.6u       ; M device
C301e 0 2 9.5m                           ; C device
M301f 0 1 3 2 NMOS L=0.25u W=88.0u AD=157.98p AS=117.29p PD=336.3u PS=312.9u ; M device
M301g 1 3 2 0 PMOS L=1.00u W=12.5u AD=15.05p AS=24.56p PD=41.4u PS=25.0u ; M device
C301h 2 3 9.2m                           ; C device
R301i 1 2 334                            ; R device
C301j 2 1 31n                            ; C device
M301k 0 1 2 3 NMOS L=0.18u W=99.5u AD=138.39p AS=138.83p PD=252.7u PS=319.2u ; M device
R301l 1 2 77k                            ; R device
C301m 1 0 1.1u                           ; C device
C301n 3 1 5.5u                           ; C device
C301o 3 0 51n                            ; C device
R301p 2 0 28k                            ; R device
C301q 0 1 69n                            ; C device
M301r 2 0 1 3 NMOS L=0.50u W=32.3u       ; M device
C301s 3 1 24n                            ; C device
R301t 2 1 8.4M                           ; R device
M301u 1 0 2 3 PMOS L=0.18u W=90.6u       ; M device
C301v 3 0 1.0u                           ; C device
M301w 3 2 1 0 NMOS L=0.10u W=88.8u AD=19.77p AS=74.85p PD=223.8u PS=323.7u ; M device
C301x 2 3 2.9m                           ; C device
R301y 1 0 46k                            ; R device
R301z 0 2 67k                            ; R device
R302a 0 2 62k                            ; R device
R302b 1 3 552                            ; R device
R302c 0 1 551                            ; R device
C302d 0 2 810p                           ; C device
R302e 0 1 9.7M                           ; R device
R302f 0 1 2.6M                           ; R device
M302g 2 1 3 0 PMOS L=1.00u W=68.8u       ; M device
M302h 2 3 1 0 NMOS L=0.18u W=15.1u AD=11.30p AS=9.12p PD=36.1u PS=44.1u ; M device
C302i 1 2 30n                            ; C device
M302j 0 2 3 1 PMOS L=0.70u W=38.6u AD=28.99p AS=54.93p PD=126.7u PS=118.5u ; M device
C302k 3 2 6.8m                           ; C device
C302l 2 3 70n                            ; C device
C302m 2 3 9.8m                           ; C device
M302n 0 1 2 3 PMOS L=0.10u W=87.1u
+ AD=155.18p AS=55.21p PD=177.8u PS=314.7u ; M device
R302o 1 2 9.0M                           ; R device
M302p 0 3 1 2 PMOS L=0.70u W=79.7u       ; M device
R302q 2 3 542                            ; R device
M302r 3 2 0 1 PMOS L=0.25u W=69.6u AD=82.69p AS=24.57p PD=222.8u PS=261.7u ; M device
C302s 3 1 9.5u                           ; C device
C302t 0 2 6.3u                           ; C device
R302u 3 0 66k                            ; R device
C302v 3 2 29n                            ; C device
R302w 3 0 6.6M                           ; R device
R302x 0 1 892                            ; R device
M302y 0 2 1 3 PMOS L=0.18u W=3.6u        ; M device
R302z 2 0 249                            ; R device
C303a 3 0 3n                             ; C device
M303b 1 0 3 2 NMOS L=0.25u W=41.4u       ; M device
R303c 2 1 6.5M                           ; R device
R303d 0 2 35k                            ; R device
M303e 0 2 1 3 PMOS L=0.13u W=62.4u AD=33.32p AS=27.08p PD=157.7u PS=129.8u ; M device
R303f 2 0 100                            ; R device
C303g 0 1 474p                           ; C device
R303h 1 0 836                            ; R device
C303i 3 0 349p                           ; C device
R303j 1 3 542                            ; R device
C303k 1 3 2.6m                           ; C device
M303l 2 0 3 1 NMOS L=0.13u W=47.0u       ; M device
R303m 2 1 49k                            ; R device
M303n 1 0 2 3 NMOS L=0.50u W=22.6u
+ AD=25.92p AS=36.67p PD=55.3u PS=57.2u ; M device
C303o 3 1 8.3u                           ; C device
C303p 2 0 47n                            ; C device
M303q 3 0 2 1 PMOS L=0.13u W=13.5u AD=12.80p AS=15.27p PD=27.1u PS=41.4u ; M device
C303r 3 1 3.4u                           ; C device
C303s 0 2 48n                            ; C device
C303t 3 2 5.3u                           ; C device
R303u 2 1 3k                             ; R device
M303v 3 1 2 0 PMOS L=0.50u W=82.3u AD=32.71p AS=76.51p PD=262.3u PS=229.6u ; M device
R303w 2 0 634                            ; R device
C303x 1 2 7.3m                           ; C device
C303y 0 2 8.1m                           ; C device
M303z 0 1 3 2 NMOS L=0.10u W=18.0u AD=12.16p AS=34.32p PD=61.2u PS=45.8u ; M device
C304a 2 1 1.5m                           ; C device
R304b 0 3 207                            ; R device
M304c 0 1 2 3 PMOS L=0.50u W=95.8u       ; M device
M304d 2 1 3 0 NMOS L=0.18u W=54.7u       ; M device
C304e 2 1 44n                            ; C device
M304f 1 3 2 0 NMOS L=1.00u W=84.6u
+ AD=37.25p AS=41.18p PD=336.5u PS=195.4u ; M device
C304g 3 0 5.0m                           ; C device
M304h 0 1 3 2 PMOS L=1.00u W=83.0u       ; M device
M304i 2 1 3 0 PMOS L=0.70u W=42.3u       ; M device
C304j 1 3 62n                            ; C device
M304k 2 3 1 0 NMOS L=1.00u W=53.9u AD=77.95p AS=100.04p PD=201.0u PS=184.5u ; M device
M304l 0 2 3 1 PMOS L=1.00u W=13.9u AD=1.99p AS=27.41p PD=49.9u PS=52.4u ; M device
M304m 0 3 1 2 PMOS L=0.70u W=6.8u
+ AD=11.87p AS=1.83p PD=13.8u PS=15.4u ; M device
C304n 3 1 0.2m                           ; C device
R304o 3 1 27k                            ; R device
M304p 2 0 1 3 NMOS L=0.35u W=48.6u       ; M device
R304q 3 1 8.9M                           ; R device
C304r 1 2 84n                            ; C device
M304s 1 2 0 3 PMOS L=0.25u W=40.9u
+ AD=67.00p AS=5.01p PD=161.1u PS=95.2u ; M device
R304t 1 2 9.0M                           ; R device
M304u 1 2 0 3 PMOS L=1.00u W=51.4u AD=68.51p AS=41.04p PD=200.2u PS=204.5u ; M device
M304v 3 2 1 0 NMOS L=0.13u W=46.7u       ; M device
R304w 3 0 89k                            ; R device
C304x 1 3 3.8m                           ; C device
M304y 0 2 1 3 NMOS L=0.10u W=61.9u       ; M device
R304z 0 1 3.6M                           ; R device
C305a 2 0 19p                            ; C device
M305b 0 1 2 3 PMOS L=0.25u W=96.7u AD=43.90p AS=192.77p PD=346.6u PS=252.7u ; M device
R305c 1 3 86k                            ; R device
C305d 0 1 337p                           ; C device
M305e 3 2 0 1 NMOS L=0.18u W=47.2u AD=24.67p AS=47.51p PD=129.2u PS=109.6u ; M device
R305f 0 2 227                            ; R device
M305g 1 2 0 3 PMOS L=0.10u W=30.0u AD=43.54p AS=7.59p PD=68.4u PS=106.3u ; M device
C305h 3 0 9.1m                           ; C device
C305i 3 2 5.9u                           ; C device
M305j 0 1 3 2 PMOS L=0.70u W=83.2u
+ AD=131.01p AS=46.48p PD=219.9u PS=312.9u ; M device
M305k 2 3 1 0 NMOS L=0.13u W=59.5u       ; M device
C305l 2 1 9.9u                           ; C device
M305m 3 1 2 0 NMOS L=0.25u W=22.7u       ; M device
R305n 3 1 438                            ; R device
R305o 0 2 55k                            ; R device
C305p 3 0 3.0m                           ; C device
M305q 3 1 0 2 PMOS L=0.70u W=65.1u       ; M device
R305r 1 2 79k                            ; R device
R305s 0 3 7.4M                           ; R device
M305t 1 0 3 2 NMOS L=0.10u W=80.9u
+ AD=12.22p AS=49.46p PD=168.6u PS=169.0u ; M device
M305u 2 1 3 0 PMOS L=1.00u W=38.3u AD=43.04p AS=57.48p PD=128.1u PS=134.1u ; M device
R305v 2 3 719                            ; R device
R305w 2 0 649                            ; R device
R305x 3 1 282                            ; R device
R305y 3 0 957                            ; R device
R305z 2 0 3.7M                           ; R device
R306a 0 1 255                            ; R device
R306b 2 3 63k                            ; R device
C306c 1 2 4.3u                           ; C device
C306d 1 0 63n                            ; C device
M306e 3 0 1 2 NMOS L=0.10u W=25.7u AD=14.70p AS=4.06p PD=93.9u PS=66.3u ; M device
R306f 0 1 6.3M                           ; R device
C306g 1 3 1.9m                           ; C device
R306h 0 3 28k                            ; R device
C306i 2 0 2.1u                           ; C device
R306j 3 0 432                            ; R device
M306k 1 0 3 2 NMOS L=0.70u W=57.0u
+ AD=77.34p AS=47.20p PD=117.2u PS=199.2u ; M device
M306l 2 0 1 3 NMOS L=0.25u W=60.6u AD=112.44p AS=31.12p PD=220.3u PS=144.4u ; M device
M306m 2 3 1 0 NMOS L=0.13u W=65.6u AD=111.32p AS=17.48p PD=163.8u PS=177.9u ; M device
C306n 3 2 3.0m                           ; C device
R306o 1 3 2.4M                           ; R device
R306p 0 3 1.8M                           ; R device
R306q 0 3 73k                            ; R device
R306r 2 3 7.9M                           ; R device
C306s 2 1 10.0u                          ; C device
M306t 3 0 1 2 NMOS L=0.25u W=18.2u AD=17.43p AS=6.72p PD=55.6u PS=72.2u ; M device
C306u 3 2 2.9m                           ; C device
C306v 3 0 5.2u                           ; C device
C306w 1 3 10.0m                          ; C device
M306x 0 2 3 1 NMOS L=0.13u W=19.2u       ; M device
M306y 0 2 3 1 NMOS L=0.10u W=65.8u
+ AD=116.43p AS=94.03p PD=262.4u PS=142.7u ; M device
R306z 1 0 904                            ; R device
R307a 1 2 87k                            ; R device
M307b 1 0 2 3 PMOS L=0.35u W=1.5u        ; M device
C307c 1 0 725p                           ; C device
C307d 2 1 0.2u                           ; C device
R307e 1 3 735                            ; R device
M307f 3 1 0 2 NMOS L=0.13u W=16.4u       ; M device
R307g 2 0 4.9M                           ; R device
M307h 0 1 2 3 PMOS L=0.50u W=69.4u       ; M device
M307i 3 2 1 0 PMOS L=0.35u W=46.2u
+ AD=69.57p AS=84.03p PD=119.4u PS=164.0u ; M device
R307j 3 0 5.4M                           ; R device
C307k 3 1 6.3u                           ; C device
C307l 3 0 26n                            ; C device
M307m 0 3 2 1 PMOS L=0.10u W=67.7u       ; M device
M307n 3 2 0 1 NMOS L=1.00u W=27.6u       ; M device
C307o 1 3 25n                            ; C device
M307p 0 1 2 3 NMOS L=1.00u W=32.9u AD=55.83p AS=27.51p PD=107.5u PS=88.5u ; M device
C307q 2 0 14n                            ; C device
C307r 1 2 97n                            ; C device
M307s 2 3 0 1 NMOS L=0.70u W=38.8u
+ AD=50.40p AS=12.06p PD=121.7u PS=146.0u ; M device
R307t 1 0 13k                            ; R device
C307u 2 3 4.4u                           ; C device
M307v 0 2 1 3 PMOS L=0.50u W=27.7u       ; M device
C307w 0 1 4.9u                           ; C device
R307x 2 3 7.2M                           ; R device
M307y 1 0 2 3 NMOS L=0.50u W=34.6u       ; M device
C307z 3 2 26n                            ; C device
C308a 1 2 7.6u                           ; C device
M308b 1 0 3 2 PMOS L=0.35u W=43.8u       ; M device
C308c 3 2 9.4u                           ; C device
M308d 0 2 3 1 NMOS L=0.50u W=51.0u
+ AD=44.53p AS=97.05p PD=181.7u PS=202.2u ; M device
R308e 2 1 686                            ; R device
C308f 0 1 3n                             ; C device
R308g 3 0 94                             ; R device
C308h 0 3 2.0u                           ; C device
C308i 1 0 8.1u                           ; C device
R308j 3 2 8k                             ; R device
R308k 2 0 110                            ; R device
C308l 1 2 79n                            ; C device
M308m 2 0 1 3 PMOS L=0.10u W=35.1u       ; M device
R308n 3 2 22k                            ; R device
C308o 0 3 2.2u                           ; C device
M308p 3 2 1 0 NMOS L=0.70u W=49.1u
+ AD=48.34p AS=53.11p PD=127.6u PS=195.0u ; M device
M308q 0 2 1 3 NMOS L=0.13u W=13.2u       ; M device
C308r 1 2 533p                           ; C device
M308s 1 3 0 2 NMOS L=0.50u W=33.9u
+ AD=6.59p AS=58.57p PD=73.4u PS=67.8u ; M device
M308t 3 0 2 1 PMOS L=0.10u W=73.6u
+ AD=67.80p AS=105.76p PD=168.2u PS=157.8u ; M device
R308u 0 1 55k                            ; R device
C308v 0 3 16n                            ; C device
C308w 0 2 14n                            ; C device
M308x 3 1 0 2 PMOS L=0.18u W=50.9u AD=50.07p AS=54.63p PD=192.2u PS=138.1u ; M device
C308y 2 1 696p                           ; C device
R308z 1 2 3.1M                           ; R device
C309a 3 1 398p                           ; C device
M309b 3 1 0 2 NMOS L=0.70u W=41.2u       ; M device
M309c 3 1 0 2 PMOS L=1.00u W=5.1u AD=0.81p AS=9.02p PD=17.6u PS=10.6u ; M device
M309d 3 2 1 0 PMOS L=0.13u W=67.4u AD=70.22p AS=97.23p PD=224.1u PS=138.6u ; M device
C309e 0 1 1.1u                           ; C device
M309f 2 0 1 3 PMOS L=1.00u W=4.0u
+ AD=4.35p AS=5.62p PD=15.1u PS=9.8u ; M device
M309g 1 0 2 3 NMOS L=0.10u W=18.9u
+ AD=20.52p AS=30.65p PD=48.4u PS=63.2u ; M device
C309h 0 2 576p                           ; C device
M309i 2 1 3 0 PMOS L=0.50u W=97.0u       ; M device
R309j 1 0 22k                            ; R device
M309k 1 2 0 3 PMOS L=0.70u W=1.6u        ; M device
M309l 0 1 3 2 NMOS L=0.10u W=63.6u AD=66.33p AS=57.17p PD=239.7u PS=138.7u ; M device
R309m 3 1 502                            ; R device
M309n 0 1 3 2 PMOS L=0.35u W=3.1u
+ AD=4.40p AS=1.84p PD=6.6u PS=11.4u ; M device
R309o 2 1 3.4M                           ; R device
M309p 2 1 0 3 NMOS L=0.35u W=48.0u       ; M device
C309q 2 0 44n                            ; C device
C309r 3 1 8.5u                           ; C device
C309s 3 2 3.0u                           ; C device
M309t 0 1 3 2 NMOS L=0.18u W=0.8u        ; M device
M309u 3 2 1 0 PMOS L=0.25u W=52.3u       ; M device
R309v 3 1 1.2M                           ; R device
C309w 2 0 398p                           ; C device
R309x 2 3 1.5M                           ; R device
M309y 1 3 0 2 NMOS L=0.18u W=20.1u       ; M device
C309z 2 1 8.2m                           ; C device
C310a 2 0 55n                            ; C device
C310b 1 3 420p                           ; C device
C310c 0 2 561p                           ; C device
R310d 1 2 45k                            ; R device
R310e 3 0 810                            ; R device
R310f 2 3 22k                            ; R device
C310g 1 0 9.1m                           ; C device
M310h 0 1 3 2 PMOS L=0.35u W=3.7u AD=2.88p AS=5.38p PD=13.2u PS=7.5u ; M device
M310i 1 0 2 3 NMOS L=0.70u W=82.7u AD=38.90p AS=51.80p PD=199.9u PS=323.4u ; M device
M310j 3 1 0 2 NMOS L=0.70u W=5.2u AD=6.37p AS=10.28p PD=16.1u PS=14.7u ; M device
C310k 3 2 1.3u                           ; C device
M310l 1 0 3 2 NMOS L=0.50u W=29.2u       ; M device
M310m 2 1 3 0 PMOS L=0.18u W=45.4u       ; M device
C310n 2 1 404p                           ; C device
R310o 2 0 8.3M                           ; R device
C310p 0 3 5.3m                           ; C device
R310q 0 3 25k                            ; R device
C310r 2 1 742p                           ; C device
R310s 2 3 68k                            ; R device
M310t 2 0 1 3 NMOS L=0.18u W=46.4u       ; M device
M310u 0 1 2 3 NMOS L=0.50u W=60.9u
+ AD=12.59p AS=68.86p PD=133.1u PS=202.5u ; M device
M310v 2 0 1 3 NMOS L=0.10u W=2.7u
+ AD=0.33p AS=4.09p PD=5.6u PS=9.2u ; M device
C310w 1 0 523p                           ; C device
R310x 2 3 383                            ; R device
C310y 1 0 4.8m                           ; C device
C310z 1 0 17n                            ; C device
R311a 0 3 2.4M                           ; R device
C311b 2 0 621p                           ; C device
C311c 0 2 9.9u                           ; C device
M311d 3 2 0 1 NMOS L=1.00u W=68.5u       ; M device
M311e 3 0 2 1 PMOS L=0.18u W=99.8u       ; M device
M311f 0 1 2 3 NMOS L=0.18u W=25.8u
+ AD=40.71p AS=30.00p PD=53.0u PS=91.3u ; M device
R311g 0 1 4.5M                           ; R device
M311h 3 0 1 2 NMOS L=0.50u W=93.7u       ; M device
C311i 3 2 6.8m                           ; C device
R311j 2 0 661                            ; R device
R311k 0 3 49k                            ; R device
M311l 1 2 3 0 NMOS L=0.35u W=7.4u
+ AD=7.13p AS=4.13p PD=20.2u PS=18.1u ; M device
M311m 2 0 3 1 PMOS L=0.70u W=33.9u       ; M device
R311n 1 0 55k                            ; R device
R311o 3 2 6k                             ; R device
R311p 3 1 27k                            ; R device
R311q 1 2 6.9M                           ; R device
C311r 3 1 991p                           ; C device
C311s 0 2 31n                            ; C device
M311t 1 0 3 2 PMOS L=1.00u W=13.6u
+ AD=22.67p AS=17.27p PD=31.9u PS=39.0u ; M device
C311u 2 3 321p                           ; C device
R311v 3 0 900                            ; R device
M311w 0 3 1 2 PMOS L=1.00u W=3.1u
+ AD=5.04p AS=4.67p PD=7.5u PS=11.1u ; M device
R311x 0 1 2.2M                           ; R device
M311y 2 3 0 1 NMOS L=0.35u W=30.4u
+ AD=21.37p AS=60.26p PD=93.7u PS=102.7u ; M device
C311z 0 1 6.7u                           ; C device
M312a 1 3 2 0 NMOS L=0.35u W=19.5u       ; M device
C312b 3 2 8.3m                           ; C device
C312c 2 1 62n                            ; C device
R312d 1 0 7k                             ; R device
C312e 3 1 53n                            ; C device
R312f 0 2 316                            ; R device
C312g 1 2 8.2m                           ; C device
R312h 1 2 3.6M                           ; R device
M312i 2 0 3 1 NMOS L=0.10u W=11.5u
+ AD=8.07p AS=10.54p PD=42.3u PS=27.7u ; M device
M312j 1 0 3 2 NMOS L=0.35u W=89.8u       ; M device
C312k 1 2 10n                            ; C device
M312l 2 3 1 0 PMOS L=0.25u W=46.8u AD=30.04p AS=30.93p PD=119.6u PS=120.7u ; M device
C312m 0 2 5.5u                           ; C device
M312n 0 2 1 3 PMOS L=1.00u W=16.8u
+ AD=20.75p AS=9.77p PD=37.8u PS=53.4u ; M device
C312o 2 0 790p                           ; C device
C312p 3 1 502p                           ; C device
M312q 1 0 3 2 PMOS L=0.35u W=2.6u AD=1.14p AS=4.19p PD=7.9u PS=6.2u ; M device
R312r 1 0 956                            ; R device
C312s 1 2 890p                           ; C device
M312t 1 3 2 0 PMOS L=0.50u W=12.9u       ; M device
M312u 0 3 2 1 PMOS L=0.18u W=59.9u       ; M device
C312v 2 3 6n                             ; C device
M312w 0 1 2 3 NMOS L=0.25u W=23.5u AD=11.99p AS=38.47p PD=69.8u PS=92.6u ; M device
M312x 1 2 3 0 NMOS L=0.50u W=3.0u
+ AD=0.30p AS=2.19p PD=6.9u PS=11.0u ; M device
M312y 1 0 3 2 NMOS L=0.18u W=22.5u       ; M device
M312z 0 3 1 2 PMOS L=0.70u W=57.9u
+ AD=111.52p AS=92.39p PD=124.5u PS=172.6u ; M device
M313a 1 2 0 3 NMOS L=0.13u W=12.4u       ; M device
C313b 1 3 892p                           ; C device
M313c 1 3 0 2 PMOS L=1.00u W=71.1u AD=35.28p AS=83.90p PD=216.2u PS=170.6u ; M device
C313d 0 2 4.5m                           ; C device
M313e 3 2 0 1 NMOS L=0.50u W=16.9u
+ AD=17.60p AS=31.46p PD=38.4u PS=61.6u ; M device
C313f 0 3 9.3m                           ; C device
M313g 1 0 3 2 PMOS L=0.35u W=15.7u       ; M device
R313h 1 0 817                            ; R device
C313i 0 1 178p                           ; C device
R313j 2 0 703                            ; R device
M313k 2 3 1 0 NMOS L=0.13u W=8.5u        ; M device
C313l 0 1 9.1m                           ; C device
R313m 2 0 46k                            ; R device
R313n 2 0 343                            ; R device
M313o 2 1 3 0 PMOS L=0.25u W=19.2u       ; M device
M313p 3 1 0 2 PMOS L=0.13u W=6.3u        ; M device
R313q 2 0 254                            ; R device
M313r 3 1 2 0 NMOS L=0.70u W=72.4u AD=62.03p AS=50.09p PD=288.1u PS=276.8u ; M device
R313s 3 2 60k                            ; R device
M313t 3 2 1 0 PMOS L=0.18u W=9.1u        ; M device
M313u 2 1 3 0 NMOS L=1.00u W=14.5u AD=23.26p AS=9.98p PD=32.2u PS=50.2u ; M device
C313v 1 0 9.1u                           ; C device
R313w 1 2 156                            ; R device
M313x 1 3 2 0 NMOS L=0.10u W=75.2u AD=48.78p AS=128.40p PD=159.0u PS=216.5u ; M device
R313y 0 1 2.4M                           ; R device
M313z 3 1 2 0 PMOS L=0.18u W=74.8u AD=148.43p AS=37.85p PD=151.0u PS=265.4u ; M device
M314a 3 0 1 2 NMOS L=0.70u W=66.7u       ; M device
C314b 0 1 0.8m                           ; C device
M314c 0 2 1 3 NMOS L=1.00u W=48.8u AD=78.27p AS=20.55p PD=157.3u PS=158.3u ; M device
C314d 1 2 454p                           ; C device
C314e 3 2 3n                             ; C device
C314f 3 0 22n                            ; C device
M314g 1 3 2 0 NMOS L=0.50u W=11.6u
+ AD=10.38p AS=15.96p PD=27.8u PS=27.6u ; M device
R314h 0 3 7k                             ; R device
M314i 2 0 3 1 NMOS L=0.10u W=33.1u       ; M device
M314j 3 2 1 0 PMOS L=0.10u W=18.7u       ; M device
M314k 0 3 1 2 PMOS L=1.00u W=18.6u       ; M device
C314l 1 3 3.0u                           ; C device
C314m 2 0 3.2u                           ; C device
M314n 1 0 3 2 NMOS L=0.13u W=59.3u AD=105.99p AS=33.33p PD=208.2u PS=233.2u ; M device
M314o 3 1 2 0 NMOS L=0.35u W=13.1u       ; M device
M314p 2 3 1 0 PMOS L=0.10u W=7.9u AD=11.32p AS=15.54p PD=27.0u PS=28.5u ; M device
M314q 1 0 3 2 PMOS L=0.70u W=74.3u       ; M device
C314r 0 1 1.2m                           ; C device
C314s 3 0 59p                            ; C device
R314t 3 1 670                            ; R device
M314u 2 0 1 3 NMOS L=0.25u W=37.4u       ; M device
R314v 2 3 33k                            ; R device
M314w 3 0 1 2 PMOS L=0.35u W=82.6u
+ AD=119.41p AS=61.73p PD=277.2u PS=320.0u ; M device
R314x 1 0 741                            ; R device
C314y 3 0 53n                            ; C device
M314z 0 2 1 3 NMOS L=0.35u W=62.7u AD=12.93p AS=74.50p PD=239.2u PS=140.8u ; M device
M315a 1 0 3 2 NMOS L=0.13u W=62.3u
+ AD=114.38p AS=74.97p PD=168.8u PS=203.9u ; M device
C315b 2 1 1.9u                           ; C device
M315c 1 3 2 0 PMOS L=0.13u W=26.1u       ; M device
R315d 1 3 50k                            ; R device
C315e 2 3 7.2u                           ; C device
C315f 0 3 3.4u                           ; C device
R315g 3 2 94k                            ; R device
M315h 1 2 0 3 NMOS L=1.00u W=59.3u AD=71.57p AS=49.09p PD=155.8u PS=132.3u ; M device
C315i 3 0 385p                           ; C device
M315j 1 3 0 2 PMOS L=0.50u W=11.0u       ; M device
R315k 2 3 900                            ; R device
C315l 2 1 49n                            ; C device
C315m 2 0 74p                            ; C device
R315n 2 0 2.0M                           ; R device
C315o 1 0 5n                             ; C device
R315p 0 3 10k                            ; R device
C315q 1 0 62p                            ; C device
M315r 3 1 0 2 NMOS L=0.35u W=2.5u        ; M device
C315s 0 3 69n                            ; C device
C315t 0 2 2.2u                           ; C device
C315u 1 0 9.4m                           ; C device
C315v 1 0 0.4m                           ; C device
C315w 2 1 88n                            ; C device
C315x 0 3 4.2u                           ; C device
M315y 0 1 3 2 NMOS L=0.18u W=25.4u
+ AD=27.12p AS=13.91p PD=84.8u PS=55.9u ; M device
C315z 0 3 69n                            ; C device
R316a 3 0 69k                            ; R device
C316b 3 1 2.6m                           ; C device
M316c 0 2 3 1 PMOS L=1.00u W=36.3u       ; M device
M316d 3 2 0 1 NMOS L=1.00u W=86.1u       ; M device
C316e 3 1 2.3m                           ; C device
M316f 0 3 2 1 NMOS L=0.70u W=69.6u
+ AD=11.22p AS=43.56p PD=236.3u PS=152.4u ; M device
R316g 3 2 46k                            ; R device
R316h 1 0 10.0M                          ; R device
R316i 0 2 6.8M                           ; R device
C316j 3 2 566p                           ; C device
M316k 2 1 0 3 PMOS L=0.35u W=73.8u       ; M device
R316l 3 1 504                            ; R device
C316m 0 3 187p                           ; C device
M316n 3 0 2 1 PMOS L=0.70u W=20.5u AD=5.93p AS=14.33p PD=68.2u PS=62.6u ; M device
C316o 3 0 2.4u                           ; C device
R316p 1 3 326                            ; R device
C316q 1 2 8.1u                           ; C device
R316r 2 3 9.4M                           ; R device
M316s 2 3 1 0 PMOS L=0.50u W=96.5u       ; M device
C316t 1 0 8.1u                           ; C device
M316u 0 3 2 1 PMOS L=0.13u W=35.0u       ; M device
C316v 1 2 0.8u                           ; C device
C316w 3 0 8.5u                           ; C device
C316x 2 1 0.5m                           ; C device
R316y 0 3 8.7M                           ; R device
R316z 2 0 5.8M                           ; R device
R317a 3 2 4.2M                           ; R device
C317b 3 0 3.4u                           ; C device
C317c 2 1 2.9m                           ; C device
M317d 1 0 2 3 PMOS L=0.70u W=23.0u AD=16.28p AS=45.62p PD=46.4u PS=51.1u ; M device
C317e 3 1 15n                            ; C device
R317f 2 0 93k                            ; R device
C317g 3 0 3n                             ; C device
R317h 2 0 3.4M                           ; R device
M317i 2 1 3 0 PMOS L=0.13u W=99.2u       ; M device
R317j 0 3 78k                            ; R device
M317k 1 2 3 0 PMOS L=0.25u W=89.2u
+ AD=32.34p AS=145.66p PD=232.7u PS=202.3u ; M device
C317l 1 3 297p                           ; C device
M317m 0 1 2 3 PMOS L=0.10u W=12.5u       ; M device
M317n 3 0 1 2 PMOS L=0.13u W=95.8u       ; M device
R317o 0 1 7.5M                           ; R device
R317p 2 1 45k                            ; R device
M317q 2 3 1 0 NMOS L=1.00u W=19.0u       ; M device
C317r 2 0 56n                            ; C device
R317s 2 1 70k                            ; R device
C317t 0 3 8.2m                           ; C device
M317u 2 1 0 3 NMOS L=0.13u W=29.9u AD=7.86p AS=42.60p PD=106.1u PS=113.8u ; M device
C317v 0 3 79n                            ; C device
M317w 0 1 3 2 NMOS L=0.70u W=5.5u AD=6.87p AS=3.78p PD=16.7u PS=16.3u ; M device
C317x 0 2 5.6m                           ; C device
C317y 2 1 1.5m                           ; C device
M317z 2 0 1 3 PMOS L=0.18u W=22.0u       ; M device
C318a 3 2 65n                            ; C device
C318b 3 2 8.6m                           ; C device
R318c 3 1 16k                            ; R device
M318d 0 3 2 1 PMOS L=0.35u W=23.9u       ; M device
R318e 2 1 7.9M                           ; R device
R318f 3 0 97k                            ; R device
C318g 0 2 0.5m                           ; C device
R318h 2 3 4.4M                           ; R device
M318i 1 2 3 0 PMOS L=0.25u W=59.5u       ; M device
R318j 0 3 0.4M                           ; R device
M318k 1 3 0 2 PMOS L=0.50u W=77.8u
+ AD=148.33p AS=75.49p PD=282.5u PS=281.3u ; M device
C318l 1 0 3.6m                           ; C device
C318m 0 2 0.7m                           ; C device
C318n 0 3 7.7m                           ; C device
C318o 3 1 2.9m                           ; C device
R318p 3 1 506                            ; R device
R318q 3 2 32k                            ; R device
R318r 1 2 24k                            ; R device
R318s 1 0 0.4M                           ; R device
C318t 3 0 91n                            ; C device
M318u 0 2 3 1 PMOS L=1.00u W=31.1u
+ AD=46.79p AS=21.94p PD=69.1u PS=68.8u ; M device
M318v 2 3 0 1 NMOS L=0.25u W=88.3u
+ AD=40.83p AS=10.36p PD=256.4u PS=265.8u ; M device
M318w 2 1 0 3 PMOS L=0.50u W=66.2u       ; M device
C318x 1 2 7.4m                           ; C device
M318y 2 0 3 1 NMOS L=0.18u W=40.3u AD=71.71p AS=32.93p PD=94.0u PS=82.5u ; M device
M318z 0 1 2 3 NMOS L=1.00u W=27.5u       ; M device
C319a 2 1 3.1u                           ; C device
C319b 1 3 19n                            ; C device
R319c 0 1 91k                            ; R device
M319d 2 1 3 0 NMOS L=0.70u W=16.2u       ; M device
R319e 3 2 2.1M                           ; R device
M319f 3 0 1 2 NMOS L=0.50u W=40.0u
+ AD=77.07p AS=27.78p PD=87.8u PS=121.2u ; M device
R319g 3 1 769                            ; R device
R319h 1 3 3.8M                           ; R device
M319i 0 1 3 2 PMOS L=0.35u W=39.3u AD=42.22p AS=36.43p PD=156.6u PS=122.1u ; M device
R319j 2 3 69k                            ; R device
M319k 3 0 1 2 PMOS L=0.50u W=97.1u
+ AD=114.13p AS=81.93p PD=264.3u PS=325.4u ; M device
R319l 1 0 4.1M                           ; R device
M319m 2 3 1 0 PMOS L=0.25u W=24.5u AD=47.19p AS=7.05p PD=86.9u PS=79.8u ; M device
R319n 1 3 22k                            ; R device
C319o 1 0 5.9u                           ; C device
C319p 2 3 582p                           ; C device
M319q 2 3 1 0 NMOS L=0.13u W=35.0u AD=23.11p AS=33.56p PD=75.0u PS=83.6u ; M device
C319r 3 2 9.3u                           ; C device
R319s 2 1 9.2M                           ; R device
R319t 2 1 755                            ; R device
C319u 3 2 1.3u                           ; C device
C319v 2 0 89n                            ; C device
M319w 3 2 1 0 NMOS L=0.25u W=65.4u       ; M device
C319x 3 2 946p                           ; C device
R319y 1 3 82k                            ; R device
C319z 0 3 869p                           ; C device
M320a 0 2 3 1 PMOS L=0.13u W=2.2u AD=3.61p AS=2.99p PD=6.5u PS=4.7u ; M device
M320b 3 0 1 2 PMOS L=0.50u W=84.3u AD=62.40p AS=96.59p PD=303.7u PS=256.7u ; M device
R320c 2 0 1.6M                           ; R device
C320d 0 2 100n                           ; C device
C320e 2 1 8.2u                           ; C device
C320f 3 2 8.4m                           ; C device
R320g 2 1 80k                            ; R device
R320h 3 0 36k                            ; R device
R320i 0 2 392                            ; R device
R320j 0 2 80                             ; R device
R320k 0 2 436                            ; R device
R320l 2 3 994                            ; R device
R320m 0 2 0.2M                           ; R device
M320n 0 3 2 1 NMOS L=0.70u W=45.2u       ; M device
M320o 3 0 1 2 PMOS L=0.25u W=67.2u
+ AD=40.91p AS=10.82p PD=139.1u PS=135.2u ; M device
R320p 3 2 1.2M                           ; R device
C320q 2 1 796p                           ; C device
C320r 3 0 5.4u                           ; C device
C320s 1 2 8.8m                           ; C device
M320t 3 0 2 1 NMOS L=0.50u W=46.5u       ; M device
R320u 2 1 100k                           ; R device
R320v 0 1 8.2M                           ; R device
R320w 1 0 8.8M                           ; R device
M320x 3 2 0 1 PMOS L=0.25u W=83.6u
+ AD=97.68p AS=81.37p PD=286.6u PS=297.7u ; M device
M320y 0 2 3 1 PMOS L=0.25u W=11.6u AD=12.29p AS=7.38p PD=42.8u PS=45.1u ; M device
R320z 2 0 7.0M                           ; R device
C321a 0 1 1.9u                           ; C device
C321b 0 3 1.0u                           ; C device
M321c 0 3 2 1 PMOS L=0.10u W=84.3u       ; M device
R321d 0 3 43k                            ; R device
M321e 0 2 1 3 NMOS L=0.18u W=45.1u AD=54.63p AS=17.37p PD=118.5u PS=91.5u ; M device
C321f 3 0 505p                           ; C device
C321g 0 1 3.7m                           ; C device
M321h 3 1 2 0 NMOS L=0.18u W=98.3u       ; M device
M321i 3 2 0 1 NMOS L=0.70u W=45.6u       ; M device
C321j 3 2 147p                           ; C device
C321k 2 1 87n                            ; C device
C321l 3 2 7.7m                           ; C device
M321m 3 0 1 2 NMOS L=0.10u W=49.9u AD=5.43p AS=78.99p PD=124.8u PS=106.9u ; M device
M321n 2 0 1 3 PMOS L=1.00u W=33.9u       ; M device
R321o 3 1 7.6M                           ; R device
C321p 0 2 838p                           ; C device
R321q 0 2 42k                            ; R device
M321r 0 2 3 1 PMOS L=0.13u W=59.4u
+ AD=115.30p AS=109.40p PD=204.1u PS=153.7u ; M device
R321s 1 0 650                            ; R device
C321t 2 3 1.6u                           ; C device
C321u 2 1 4.5u                           ; C device
M321v 1 0 2 3 PMOS L=0.13u W=5.1u        ; M device
C321w 0 3 3.7u                           ; C device
C321x 0 2 2.1m                           ; C device
R321y 0 1 20k                            ; R device
R321z 2 3 65k                            ; R device
C322a 2 0 5.1m                           ; C device
C322b 1 0 3.8m                           ; C device
M322c 0 1 2 3 NMOS L=0.35u W=4.8u        ; M device
C322d 1 0 49n                            ; C device
R322e 1 3 9.6M                           ; R device
M322f 1 3 2 0 PMOS L=0.10u W=40.2u
+ AD=34.74p AS=26.57p PD=126.3u PS=121.3u ; M device
M322g 2 1 0 3 NMOS L=1.00u W=61.9u
+ AD=58.75p AS=34.86p PD=128.8u PS=224.4u ; M device
M322h 3 2 0 1 NMOS L=0.35u W=7.9u        ; M device
M322i 0 2 3 1 NMOS L=0.70u W=75.3u AD=129.85p AS=54.38p PD=277.7u PS=178.4u ; M device
M322j 2 3 0 1 NMOS L=0.18u W=87.9u       ; M device
M322k 2 3 1 0 NMOS L=0.13u W=40.1u       ; M device
C322l 1 0 0.2m                           ; C device
M322m 3 1 0 2 PMOS L=0.10u W=77.9u       ; M device
R322n 0 2 997                            ; R device
R322o 0 2 30k                            ; R device
M322p 2 0 1 3 NMOS L=0.25u W=16.3u AD=15.85p AS=17.29p PD=41.4u PS=33.4u ; M device
R322q 0 3 4.4M                           ; R device
C322r 2 0 9.5u                           ; C device
C322s 2 0 2.7m                           ; C device
C322t 2 3 7.2u                           ; C device
M322u 3 1 2 0 NMOS L=0.18u W=56.9u AD=39.61p AS=7.26p PD=208.4u PS=118.1u ; M device
M322v 2 3 1 0 NMOS L=0.25u W=82.6u
+ AD=35.84p AS=23.32p PD=305.8u PS=330.0u ; M device
R322w 3 0 3.6M                           ; R device
C322x 1 0 3.8u                           ; C device
M322y 2 0 3 1 PMOS L=0.25u W=31.8u       ; M device
M322z 3 2 1 0 NMOS L=0.35u W=6.2u AD=3.24p AS=5.87p PD=22.5u PS=23.1u ; M device
C323a 0 1 36n                            ; C device
M323b 2 1 3 0 PMOS L=0.10u W=56.8u
+ AD=7.22p AS=13.69p PD=125.5u PS=140.2u ; M device
M323c 3 2 1 0 PMOS L=0.25u W=82.1u
+ AD=67.97p AS=159.78p PD=259.6u PS=325.8u ; M device
M323d 1 0 2 3 PMOS L=0.18u W=38.3u AD=38.43p AS=76.35p PD=106.8u PS=118.6u ; M device
M323e 0 3 1 2 NMOS L=0.35u W=70.8u
+ AD=113.30p AS=136.70p PD=205.5u PS=194.8u ; M device
C323f 2 1 2.1u                           ; C device
M323g 2 0 1 3 NMOS L=0.10u W=41.0u       ; M device
R323h 3 0 80k                            ; R device
C323i 1 2 0.7u                           ; C device
M323j 2 0 3 1 NMOS L=0.70u W=69.1u       ; M device
R323k 0 2 7.1M                           ; R device
M323l 3 1 2 0 NMOS L=0.50u W=58.7u
+ AD=32.98p AS=40.40p PD=156.4u PS=159.2u ; M device
R323m 2 0 90k                            ; R device
M323n 2 3 0 1 PMOS L=0.50u W=57.3u       ; M device
R323o 1 3 1.3M                           ; R device
M323p 0 2 3 1 NMOS L=0.35u W=36.3u
+ AD=50.51p AS=33.37p PD=92.0u PS=131.2u ; M device
R323q 3 0 9.9M                           ; R device
M323r 1 3 0 2 NMOS L=0.10u W=40.4u
+ AD=10.34p AS=29.06p PD=87.7u PS=124.1u ; M device
C323s 1 0 350p                           ; C device
M323t 0 2 1 3 PMOS L=0.25u W=54.9u       ; M device
M323u 2 3 0 1 NMOS L=0.18u W=11.1u AD=6.25p AS=4.86p PD=34.4u PS=32.1u ; M device
C323v 3 0 8.0u                           ; C device
M323w 1 0 2 3 PMOS L=1.00u W=89.1u       ; M device
R323x 2 0 6.8M                           ; R device
M323y 0 2 3 1 NMOS L=0.25u W=83.9u       ; M device
R323z 2 0 39k                            ; R device
M324a 1 2 0 3 NMOS L=0.50u W=92.6u       ; M device
M324b 1 3 0 2 NMOS L=0.10u W=61.0u       ; M device
C324c 2 3 222p                           ; C device
R324d 3 2 8.9M                           ; R device
C324e 1 2 420p                           ; C device
R324f 1 0 940                            ; R device
C324g 0 3 19n                            ; C device
C324h 1 0 3.7u                           ; C device
M324i 2 3 1 0 NMOS L=1.00u W=23.0u       ; M device
C324j 2 0 985p                           ; C device
C324k 2 1 26n                            ; C device
C324l 0 2 842p                           ; C device
C324m 3 0 2.0m                           ; C device
C324n 1 0 3.1u                           ; C device
C324o 3 1 9.6u                           ; C device
C324p 2 0 910p                           ; C device
C324q 0 3 47n                            ; C device
C324r 0 2 876p                           ; C device
C324s 3 2 750p                           ; C device
C324t 0 2 9p                             ; C device
R324u 0 3 18k                            ; R device
R324v 2 3 9.5M                           ; R device
C324w 0 1 538p                           ; C device
R324x 1 3 108                            ; R device
C324y 3 0 4.3u                           ; C device
M324z 1 2 0 3 NMOS L=0.70u W=23.0u       ; M device
R325a 0 3 3k                             ; R device
C325b 3 0 7.9u                           ; C device
M325c 0 3 1 2 PMOS L=0.35u W=21.0u       ; M device
R325d 0 2 466                            ; R device
M325e 3 1 2 0 NMOS L=0.25u W=56.1u
+ AD=80.20p AS=35.81p PD=137.7u PS=174.2u ; M device
R325f 3 1 965                            ; R device
R325g 1 2 9k                             ; R device
C325h 0 2 62n                            ; C device
M325i 1 3 2 0 NMOS L=0.35u W=25.0u
+ AD=21.05p AS=49.40p PD=87.3u PS=52.1u ; M device
R325j 3 1 6k                             ; R device
M325k 2 0 1 3 NMOS L=0.10u W=33.9u       ; M device
R325l 2 3 58k                            ; R device
C325m 3 0 733p                           ; C device
C325n 3 2 8.5m                           ; C device
R325o 3 0 90k                            ; R device
R325p 0 1 25k                            ; R device
M325q 2 1 3 0 PMOS L=0.70u W=0.9u        ; M device
R325r 0 1 635                            ; R device
M325s 1 2 3 0 NMOS L=1.00u W=64.8u
+ AD=10.90p AS=59.48p PD=258.3u PS=201.5u ; M device
M325t 2 3 1 0 PMOS L=0.35u W=98.8u
+ AD=115.41p AS=152.19p PD=269.3u PS=265.1u ; M device
M325u 3 2 0 1 NMOS L=1.00u W=89.8u       ; M device
M325v 1 0 2 3 NMOS L=0.35u W=85.5u AD=129.51p AS=152.89p PD=184.6u PS=257.7u ; M device
C325w 1 0 6.9u                           ; C device
R325x 1 3 5.9M                           ; R device
M325y 0 1 2 3 NMOS L=0.70u W=69.2u AD=132.80p AS=123.52p PD=254.7u PS=223.0u ; M device
C325z 1 2 799p                           ; C device
R326a 3 2 6.0M                           ; R device
R326b 2 3 47k                            ; R device
C326c 3 0 574p                           ; C device
M326d 2 1 3 0 NMOS L=0.25u W=59.7u       ; M device
M326e 0 1 3 2 NMOS L=0.13u W=49.5u
+ AD=15.44p AS=47.63p PD=140.3u PS=160.7u ; M device
C326f 0 1 42n                            ; C device
M326g 0 2 1 3 PMOS L=0.50u W=92.3u AD=83.55p AS=21.82p PD=331.2u PS=324.5u ; M device
C326h 2 1 6.5u                           ; C device
C326i 2 3 91n                            ; C device
R326j 0 3 274                            ; R device
R326k 0 1 705                            ; R device
C326l 0 3 61n                            ; C device
M326m 2 1 0 3 PMOS L=0.50u W=95.1u       ; M device
C326n 1 0 25n                            ; C device
C326o 2 3 4.3m                           ; C device
R326p 2 0 14k                            ; R device
M326q 2 0 1 3 NMOS L=0.70u W=88.7u       ; M device
C326r 2 1 176p                           ; C device
M326s 0 1 2 3 PMOS L=0.13u W=38.1u       ; M device
M326t 1 3 2 0 NMOS L=0.25u W=60.7u
+ AD=71.67p AS=34.09p PD=176.8u PS=229.4u ; M device
M326u 2 1 3 0 PMOS L=0.70u W=83.6u AD=84.01p AS=135.08p PD=214.7u PS=191.5u ; M device
M326v 1 3 0 2 NMOS L=0.18u W=79.9u AD=71.84p AS=15.32p PD=162.8u PS=276.3u ; M device
C326w 2 1 5.0m                           ; C device
R326x 3 0 641                            ; R device
M326y 3 2 1 0 NMOS L=0.70u W=63.6u
+ AD=20.87p AS=120.09p PD=159.7u PS=248.7u ; M device
M326z 0 3 2 1 NMOS L=0.10u W=38.8u AD=56.38p AS=43.69p PD=124.0u PS=142.1u ; M device
C327a 3 0 568p                           ; C device
R327b 1 0 92                             ; R device
R327c 0 2 39k                            ; R device
R327d 2 1 26k                            ; R device
R327e 0 2 598                            ; R device
C327f 2 1 56n                            ; C device
M327g 1 2 0 3 PMOS L=0.35u W=41.2u       ; M device
C327h 0 1 6.2m                           ; C device
C327i 3 2 4.7u                           ; C device
M327j 2 0 1 3 PMOS L=1.00u W=57.3u       ; M device
C327k 0 3 7.3u                           ; C device
M327l 3 1 0 2 PMOS L=1.00u W=83.1u       ; M device
R327m 0 1 77k                            ; R device
M327n 0 1 2 3 NMOS L=1.00u W=82.2u AD=89.72p AS=73.14p PD=189.8u PS=265.1u ; M device
M327o 0 1 3 2 NMOS L=1.00u W=73.5u       ; M device
R327p 1 3 365                            ; R device
R327q 3 0 42k                            ; R device
C327r 1 3 687p                           ; C device
C327s 1 2 63n                            ; C device
R327t 2 3 478                            ; R device
M327u 3 0 2 1 NMOS L=0.25u W=5.5u AD=8.81p AS=6.74p PD=13.3u PS=19.4u ; M device
M327v 0 2 1 3 NMOS L=0.18u W=94.1u       ; M device
C327w 1 0 5.6u                           ; C device
C327x 1 0 43n                            ; C device
C327y 0 3 307p                           ; C device
R327z 1 2 8.5M                           ; R device
M328a 3 2 1 0 NMOS L=0.70u W=27.5u       ; M device
C328b 1 0 8.0u                           ; C device
C328c 0 3 7.5m                           ; C device
M328d 3 0 1 2 NMOS L=0.70u W=62.6u       ; M device
M328e 2 1 0 3 NMOS L=1.00u W=48.8u       ; M device
R328f 2 0 98k                            ; R device
R328g 3 2 97k                            ; R device
M328h 2 0 1 3 PMOS L=0.70u W=33.2u AD=41.64p AS=3.86p PD=114.1u PS=116.1u ; M device
M328i 2 3 0 1 PMOS L=1.00u W=86.3u
+ AD=37.76p AS=31.63p PD=332.2u PS=215.7u ; M device
C328j 0 3 5.1m                           ; C device
M328k 1 3 2 0 NMOS L=1.00u W=98.9u       ; M device
C328l 1 0 1.2u                           ; C device
M328m 2 1 0 3 NMOS L=0.70u W=4.2u        ; M device
R328n 0 3 906                            ; R device
C328o 0 2 635p                           ; C device
R328p 1 2 0.4M                           ; R device
C328q 0 3 7.5u                           ; C device
R328r 3 1 697                            ; R device
M328s 0 2 1 3 PMOS L=0.70u W=5.9u AD=3.91p AS=5.74p PD=14.5u PS=16.6u ; M device
C328t 3 1 78n                            ; C device
R328u 3 2 29k                            ; R device
C328v 3 1 87n                            ; C device
M328w 0 3 2 1 NMOS L=0.18u W=27.0u       ; M device
C328x 3 2 8.5m                           ; C device
M328y 0 3 1 2 PMOS L=0.35u W=43.3u AD=56.42p AS=9.32p PD=88.9u PS=171.8u ; M device
R328z 2 0 917                            ; R device
R329a 3 2 0.7M                           ; R device
R329b 2 0 8.8M                           ; R device
R329c 1 3 7.4M                           ; R device
R329d 1 0 30k                            ; R device
C329e 0 3 9.6m                           ; C device
R329f 0 3 7.5M                           ; R device
R329g 1 0 0.8M                           ; R device
C329h 3 2 73n                            ; C device
M329i 1 0 2 3 PMOS L=0.50u W=92.5u       ; M device
M329j 0 3 1 2 NMOS L=0.50u W=46.8u       ; M device
C329k 2 0 6.8u                           ; C device
R329l 0 1 57k                            ; R device
M329m 1 0 3 2 PMOS L=0.70u W=33.2u       ; M device
C329n 2 3 3.8u                           ; C device
M329o 2 3 1 0 NMOS L=0.35u W=67.1u AD=41.09p AS=90.76p PD=239.5u PS=222.2u ; M device
R329p 0 2 31k                            ; R device
M329q 0 1 3 2 PMOS L=0.18u W=86.5u AD=132.10p AS=42.50p PD=235.2u PS=290.0u ; M device
R329r 1 2 822                            ; R device
R329s 0 2 840                            ; R device
R329t 2 3 91k                            ; R device
C329u 3 2 65n                            ; C device
R329v 1 3 6.6M                           ; R device
C329w 0 2 4.7u                           ; C device
M329x 1 2 0 3 PMOS L=0.18u W=84.1u       ; M device
C329y 0 3 8.9u                           ; C device
R329z 2 1 9.1M                           ; R device
R330a 3 2 393                            ; R device
C330b 0 3 8.6m                           ; C device
C330c 3 0 1.8u                           ; C device
M330d 3 2 0 1 PMOS L=0.25u W=81.8u       ; M device
C330e 1 3 638p                           ; C device
M330f 1 3 0 2 NMOS L=0.18u W=31.9u       ; M device
R330g 1 2 4.0M                           ; R device
M330h 0 2 3 1 PMOS L=0.25u W=98.9u       ; M device
M330i 3 1 0 2 NMOS L=0.50u W=11.3u
+ AD=1.40p AS=17.07p PD=33.2u PS=40.4u ; M device
C330j 2 0 73n                            ; C device
M330k 3 2 1 0 NMOS L=0.10u W=60.5u AD=30.95p AS=82.76p PD=155.1u PS=217.5u ; M device
M330l 1 2 3 0 PMOS L=0.50u W=49.6u
+ AD=94.20p AS=84.20p PD=166.9u PS=150.3u ; M device
R330m 2 3 8.2M                           ; R device
M330n 3 2 0 1 PMOS L=0.70u W=95.8u AD=31.70p AS=143.50p PD=353.3u PS=314.1u ; M device
M330o 3 1 0 2 NMOS L=1.00u W=57.3u       ; M device
M330p 1 3 2 0 PMOS L=0.50u W=61.1u       ; M device
C330q 2 0 21n                            ; C device
R330r 0 2 28k                            ; R device
C330s 1 2 3n                             ; C device
C330t 1 2 7.5m                           ; C device
R330u 0 3 15k                            ; R device
R330v 3 1 281                            ; R device
M330w 3 0 1 2 PMOS L=0.13u W=91.4u
+ AD=159.50p AS=133.10p PD=329.3u PS=236.0u ; M device
C330x 3 0 4.2m                           ; C device
R330y 1 0 70                             ; R device
R330z 3 1 25k                            ; R device
M331a 2 3 1 0 NMOS L=0.10u W=10.6u AD=13.74p AS=9.93p PD=28.6u PS=41.5u ; M device
R331b 1 3 3.1M                           ; R device
M331c 3 2 1 0 PMOS L=0.13u W=83.1u       ; M device
M331d 1 2 3 0 NMOS L=0.10u W=23.8u       ; M device
C331e 1 3 531p                           ; C device
C331f 1 0 3.2m                           ; C device
M331g 2 1 3 0 PMOS L=0.50u W=22.3u       ; M device
R331h 3 1 44k                            ; R device
R331i 0 1 6.6M                           ; R device
R331j 2 1 73k                            ; R device
R331k 0 1 78k                            ; R device
C331l 3 1 4.2m                           ; C device
M331m 1 3 2 0 PMOS L=0.50u W=8.9u
+ AD=11.39p AS=1.10p PD=18.8u PS=24.5u ; M device
M331n 2 1 3 0 PMOS L=1.00u W=40.7u
+ AD=39.40p AS=62.00p PD=144.7u PS=100.0u ; M device
M331o 2 3 0 1 NMOS L=0.50u W=67.1u AD=30.22p AS=55.86p PD=205.8u PS=190.7u ; M device
R331p 3 0 4.7M                           ; R device
M331q 1 3 2 0 PMOS L=0.70u W=70.2u       ; M device
M331r 0 3 1 2 NMOS L=0.25u W=26.8u       ; M device
R331s 3 0 59k                            ; R device
M331t 0 3 2 1 NMOS L=0.25u W=69.6u       ; M device
C331u 2 1 951p                           ; C device
M331v 1 0 2 3 PMOS L=0.18u W=25.4u
+ AD=48.93p AS=25.75p PD=63.3u PS=89.3u ; M device
C331w 0 2 98n                            ; C device
R331x 3 1 70k                            ; R device
C331y 1 3 7.3u                           ; C device
M331z 1 0 2 3 PMOS L=0.13u W=38.2u
+ AD=41.81p AS=8.08p PD=114.4u PS=128.0u ; M device
R332a 2 3 323                            ; R device
C332b 0 1 3.0m                           ; C device
M332c 1 2 3 0 NMOS L=0.35u W=50.1u       ; M device
C332d 1 3 6.9m                           ; C device
M332e 2 3 1 0 PMOS L=0.25u W=44.2u
+ AD=51.72p AS=81.98p PD=110.2u PS=141.8u ; M device
M332f 0 3 2 1 NMOS L=1.00u W=89.5u AD=124.15p AS=75.50p PD=297.1u PS=207.7u ; M device
R332g 2 0 1.6M                           ; R device
C332h 1 2 1.9m                           ; C device
C332i 0 2 2.5u                           ; C device
M332j 1 3 0 2 NMOS L=0.25u W=79.9u
+ AD=123.56p AS=101.81p PD=282.5u PS=276.5u ; M device
M332k 1 3 0 2 PMOS L=0.35u W=87.2u AD=136.41p AS=46.43p PD=200.8u PS=188.8u ; M device
R332l 1 3 23k                            ; R device
C332m 0 3 2.0m                           ; C device
M332n 3 2 1 0 NMOS L=0.35u W=14.1u       ; M device
M332o 1 3 0 2 PMOS L=0.10u W=86.1u
+ AD=156.35p AS=142.86p PD=204.2u PS=254.0u ; M device
M332p 3 2 0 1 PMOS L=0.13u W=82.7u AD=21.98p AS=124.55p PD=229.4u PS=298.6u ; M device
M332q 1 2 0 3 NMOS L=0.50u W=13.8u AD=9.14p AS=23.44p PD=51.8u PS=35.1u ; M device
C332r 3 0 13n                            ; C device
R332s 1 2 339                            ; R device
C332t 3 0 1.7m                           ; C device
C332u 0 2 49n                            ; C device
C332v 1 0 0.5u                           ; C device
C332w 3 0 67n                            ; C device
C332x 3 1 5.2m                           ; C device
M332y 0 1 3 2 NMOS L=0.50u W=88.2u       ; M device
R332z 0 2 155                            ; R device
M333a 2 3 0 1 NMOS L=0.50u W=93.3u
+ AD=28.55p AS=31.17p PD=357.7u PS=220.8u ; M device
C333b 0 2 759p                           ; C device
M333c 3 2 0 1 PMOS L=0.50u W=93.3u       ; M device
R333d 0 1 6.9M                           ; R device
R333e 0 3 0.4M                           ; R device
R333f 3 2 3.6M                           ; R device
C333g 3 2 576p                           ; C device
C333h 0 2 338p                           ; C device
R333i 1 0 114                            ; R device
M333j 0 2 1 3 NMOS L=0.70u W=32.2u       ; M device
C333k 2 3 47n                            ; C device
C333l 1 3 4.9u                           ; C device
M333m 1 2 3 0 PMOS L=1.00u W=45.7u
+ AD=81.29p AS=10.16p PD=165.8u PS=111.4u ; M device
R333n 2 1 63k                            ; R device
C333o 0 2 13n                            ; C device
C333p 0 3 78n                            ; C device
R333q 0 1 356                            ; R device
M333r 3 0 2 1 PMOS L=0.70u W=27.6u AD=50.99p AS=32.02p PD=97.7u PS=60.2u ; M device
C333s 0 1 251p                           ; C device
R333t 3 0 1.3M                           ; R device
R333u 2 1 57k                            ; R device
R333v 1 2 564                            ; R device
C333w 3 1 3.7u                           ; C device
M333x 0 2 3 1 PMOS L=0.10u W=64.5u AD=89.23p AS=80.56p PD=130.1u PS=254.5u ; M device
M333y 0 1 3 2 NMOS L=0.35u W=76.7u       ; M device
R333z 2 0 4.5M                           ; R device
R334a 3 0 209                            ; R device
R334b 3 1 17k                            ; R device
C334c 0 2 2.6u                           ; C device
C334d 1 2 0.5u                           ; C device
C334e 3 0 4.3u                           ; C device
C334f 0 2 51p                            ; C device
C334g 1 0 5.7u                           ; C device
R334h 3 2 7.0M                           ; R device
R334i 0 1 96k                            ; R device
M334j 1 3 2 0 NMOS L=1.00u W=70.9u       ; M device
M334k 0 2 3 1 PMOS L=0.13u W=15.4u       ; M device
R334l 2 1 40k                            ; R device
M334m 0 2 1 3 PMOS L=0.10u W=25.4u       ; M device
R334n 0 1 89k                            ; R device
C334o 3 0 3.1u                           ; C device
C334p 0 1 37n                            ; C device
M334q 2 3 1 0 NMOS L=0.70u W=27.7u
+ AD=47.26p AS=25.21p PD=109.5u PS=66.1u ; M device
M334r 1 2 3 0 PMOS L=1.00u W=41.0u       ; M device
M334s 2 3 0 1 PMOS L=0.35u W=28.8u
+ AD=21.48p AS=55.55p PD=114.8u PS=93.6u ; M device
R334t 2 3 76k                            ; R device
C334u 3 2 620p                           ; C device
M334v 0 2 3 1 NMOS L=0.18u W=55.1u       ; M device
C334w 0 3 177p                           ; C device
M334x 2 3 0 1 PMOS L=0.10u W=49.1u
+ AD=52.84p AS=84.60p PD=122.3u PS=178.4u ; M device
C334y 1 0 370p                           ; C device
R334z 1 3 93k                            ; R device
R335a 3 1 1k                             ; R device
M335b 3 1 2 0 NMOS L=0.18u W=29.1u AD=10.04p AS=38.38p PD=108.4u PS=86.2u ; M device
C335c 3 1 8.6m                           ; C device
C335d 3 1 826p                           ; C device
M335e 0 1 2 3 NMOS L=0.70u W=83.7u
+ AD=9.88p AS=110.68p PD=184.9u PS=175.4u ; M device
M335f 0 1 3 2 NMOS L=0.35u W=98.6u AD=46.46p AS=28.04p PD=379.0u PS=374.0u ; M device
M335g 1 2 0 3 PMOS L=0.50u W=84.9u
+ AD=101.13p AS=15.27p PD=200.4u PS=191.6u ; M device
R335h 3 0 39k                            ; R device
M335i 2 3 0 1 PMOS L=1.00u W=80.3u
+ AD=57.11p AS=157.37p PD=223.8u PS=201.1u ; M device
C335j 1 0 7.6m                           ; C device
C335k 3 0 8.0u                           ; C device
C335l 1 0 8.8u                           ; C device
R335m 2 1 7.4M                           ; R device
R335n 2 3 933                            ; R device
M335o 1 3 2 0 NMOS L=0.13u W=99.8u       ; M device
M335p 3 1 2 0 PMOS L=0.70u W=10.6u AD=7.64p AS=13.89p PD=32.0u PS=22.3u ; M device
C335q 0 1 4n                             ; C device
R335r 0 1 522                            ; R device
M335s 2 0 1 3 PMOS L=0.50u W=33.5u       ; M device
R335t 1 0 5.1M                           ; R device
M335u 2 1 3 0 NMOS L=0.70u W=1.3u AD=0.58p AS=2.17p PD=3.2u PS=5.3u ; M device
R335v 2 3 2.9M                           ; R device
C335w 0 1 6.3u                           ; C device
R335x 0 1 47k                            ; R device
C335y 3 1 2.0u                           ; C device
M335z 0 2 1 3 PMOS L=0.13u W=65.2u
+ AD=80.96p AS=12.22p PD=243.0u PS=258.6u ; M device
C336a 0 3 0.4m                           ; C device
M336b 0 2 3 1 PMOS L=0.50u W=88.0u AD=78.41p AS=71.23p PD=297.8u PS=313.3u ; M device
C336c 0 2 76p                            ; C device
C336d 3 1 8.2u                           ; C device
M336e 0 2 3 1 PMOS L=0.50u W=46.9u AD=72.71p AS=81.66p PD=144.9u PS=105.2u ; M device
C336f 2 3 5.5u                           ; C device
M336g 0 2 1 3 NMOS L=0.13u W=98.8u
+ AD=59.17p AS=28.46p PD=226.6u PS=273.6u ; M device
C336h 1 2 2.9u                           ; C device
M336i 2 3 0 1 NMOS L=0.50u W=77.3u
+ AD=149.62p AS=129.80p PD=290.6u PS=291.6u ; M device
M336j 0 2 1 3 NMOS L=0.35u W=38.9u       ; M device
C336k 2 3 83n                            ; C device
C336l 2 3 9.4m                           ; C device
R336m 2 1 2.1M                           ; R device
R336n 1 2 2.1M                           ; R device
C336o 3 2 9.3m                           ; C device
C336p 3 0 0.2u                           ; C device
R336q 1 0 46k                            ; R device
M336r 0 2 3 1 PMOS L=0.18u W=28.1u AD=23.37p AS=13.88p PD=85.6u PS=101.6u ; M device
R336s 1 0 3.8M                           ; R device
C336t 0 3 963p                           ; C device
M336u 2 1 0 3 NMOS L=0.70u W=82.5u       ; M device
R336v 2 1 252                            ; R device
R336w 0 2 247                            ; R device
M336x 3 0 1 2 PMOS L=0.70u W=86.1u       ; M device
R336y 3 0 813                            ; R device
R336z 1 0 32k                            ; R device
M337a 0 1 2 3 PMOS L=0.50u W=70.4u AD=102.98p AS=99.57p PD=208.7u PS=186.1u ; M device
R337b 2 1 3.9M                           ; R device
C337c 2 0 81n                            ; C device
R337d 2 3 918                            ; R device
R337e 1 2 4.0M                           ; R device
R337f 0 1 86k                            ; R device
R337g 1 3 925                            ; R device
R337h 1 2 47k                            ; R device
C337i 3 0 305p                           ; C device
C337j 0 3 0.2u                           ; C device
C337k 3 1 0.6u                           ; C device
M337l 0 1 3 2 PMOS L=0.18u W=62.4u
+ AD=48.32p AS=51.65p PD=137.5u PS=236.8u ; M device
M337m 2 0 3 1 PMOS L=0.10u W=4.2u
+ AD=4.92p AS=7.50p PD=9.4u PS=10.0u ; M device
R337n 1 2 87                             ; R device
M337o 3 1 2 0 PMOS L=0.70u W=16.1u
+ AD=14.93p AS=32.00p PD=42.4u PS=63.3u ; M device
C337p 3 0 983p                           ; C device
C337q 2 0 4.9m                           ; C device
M337r 3 0 1 2 NMOS L=0.13u W=2.2u
+ AD=1.57p AS=1.80p PD=5.9u PS=6.7u ; M device
R337s 0 2 7.6M                           ; R device
M337t 3 0 1 2 NMOS L=0.35u W=63.8u       ; M device
M337u 3 1 2 0 NMOS L=0.10u W=26.9u       ; M device
C337v 0 1 51n                            ; C device
C337w 1 3 40n                            ; C device
M337x 1 0 3 2 PMOS L=0.50u W=35.4u       ; M device
R337y 3 1 7.7M                           ; R device
R337z 1 0 5.0M                           ; R device
R338a 3 0 95                             ; R device
C338b 3 2 0.3m                           ; C device
C338c 3 0 1.3m                           ; C device
M338d 1 0 2 3 NMOS L=0.13u W=69.9u
+ AD=34.58p AS=82.11p PD=264.1u PS=269.4u ; M device
M338e 0 3 1 2 PMOS L=0.13u W=30.2u       ; M device
M338f 3 2 1 0 NMOS L=0.70u W=20.9u       ; M device
M338g 1 2 0 3 PMOS L=0.18u W=26.4u
+ AD=22.89p AS=13.87p PD=88.7u PS=89.7u ; M device
R338h 3 1 1.9M                           ; R device
R338i 1 0 65k                            ; R device
R338j 0 2 40k                            ; R device
C338k 2 0 47n                            ; C device
M338l 2 1 0 3 NMOS L=0.18u W=3.6u AD=3.09p AS=5.01p PD=13.3u PS=7.5u ; M device
M338m 1 2 0 3 NMOS L=0.18u W=73.4u AD=87.53p AS=117.86p PD=159.5u PS=271.7u ; M device
M338n 1 2 3 0 PMOS L=0.25u W=91.2u AD=102.85p AS=70.41p PD=314.9u PS=237.1u ; M device
C338o 3 1 5n                             ; C device
M338p 3 2 1 0 NMOS L=0.10u W=92.4u AD=119.32p AS=167.11p PD=357.4u PS=237.2u ; M device
M338q 1 2 3 0 PMOS L=0.10u W=93.5u       ; M device
C338r 3 1 59n                            ; C device
R338s 0 3 828                            ; R device
C338t 3 2 9.0u                           ; C device
C338u 0 2 676p                           ; C device
R338v 1 2 3.2M                           ; R device
C338w 2 1 392p                           ; C device
C338x 1 3 663p                           ; C device
C338y 2 0 7.6u                           ; C device
R338z 1 0 3.4M                           ; R device
M339a 2 1 0 3 PMOS L=0.25u W=46.7u
+ AD=90.76p AS=52.37p PD=97.2u PS=143.8u ; M device
R339b 1 2 222                            ; R device
M339c 1 3 2 0 NMOS L=0.25u W=39.8u       ; M device
M339d 1 0 2 3 PMOS L=0.13u W=37.0u       ; M device
M339e 0 3 2 1 PMOS L=0.70u W=78.4u AD=132.40p AS=69.45p PD=203.3u PS=296.9u ; M device
R339f 3 1 5.3M                           ; R device
M339g 3 2 1 0 NMOS L=0.50u W=15.2u AD=27.70p AS=13.65p PD=39.9u PS=37.9u ; M device
M339h 1 3 0 2 NMOS L=0.18u W=73.0u       ; M device
M339i 0 1 2 3 PMOS L=0.10u W=34.5u AD=49.56p AS=65.43p PD=101.2u PS=77.7u ; M device
R339j 1 2 95k                            ; R device
R339k 1 3 886                            ; R device
R339l 2 1 4.2M                           ; R device
C339m 3 1 91n                            ; C device
C339n 3 1 350p                           ; C device
M339o 2 0 3 1 PMOS L=0.13u W=58.4u       ; M device
C339p 0 2 1.5u                           ; C device
C339q 0 1 7.6m                           ; C device
C339r 2 0 0.6m                           ; C device
R339s 0 2 89k                            ; R device
C339t 0 3 6n                             ; C device
M339u 1 3 0 2 NMOS L=0.10u W=94.2u AD=67.13p AS=39.37p PD=343.5u PS=258.9u ; M device
R339v 2 3 9.1M                           ; R device
R339w 3 0 41k                            ; R device
R339x 2 0 5.8M                           ; R device
C339y 2 0 144p                           ; C device
C339z 3 0 4.4u                           ; C device
M340a 3 1 2 0 PMOS L=0.35u W=86.3u       ; M device
R340b 1 2 23k                            ; R device
R340c 0 3 713                            ; R device
C340d 2 0 18n                            ; C device
R340e 2 3 4.8M                           ; R device
R340f 1 2 494                            ; R device
M340g 0 3 1 2 NMOS L=0.25u W=4.3u        ; M device
C340h 0 1 3.1m                           ; C device
R340i 0 3 422                            ; R device
R340j 0 1 42k                            ; R device
R340k 1 0 0.6M                           ; R device
R340l 2 1 3k                             ; R device
R340m 2 1 232                            ; R device
C340n 1 2 5p                             ; C device
R340o 0 1 6.8M                           ; R device
R340p 1 2 9.7M                           ; R device
R340q 3 2 3.2M                           ; R device
M340r 2 3 1 0 NMOS L=0.35u W=38.3u       ; M device
M340s 1 3 2 0 NMOS L=1.00u W=67.8u       ; M device
M340t 2 1 0 3 PMOS L=0.13u W=28.5u       ; M device
R340u 1 0 39k                            ; R device
C340v 2 0 595p                           ; C device
M340w 3 1 2 0 NMOS L=0.10u W=20.8u       ; M device
M340x 2 3 0 1 PMOS L=0.10u W=22.1u AD=42.08p AS=42.83p PD=65.4u PS=50.2u ; M device
C340y 2 0 6.7u                           ; C device
C340z 2 1 953p                           ; C device
R341a 2 1 79k                            ; R device
M341b 3 1 0 2 PMOS L=0.18u W=56.7u AD=87.58p AS=24.26p PD=120.3u PS=168.2u ; M device
M341c 1 3 2 0 NMOS L=0.25u W=82.4u       ; M device
C341d 2 0 53n                            ; C device
R341e 1 0 5.7M                           ; R device
C341f 3 2 8.1m                           ; C device
M341g 3 2 1 0 NMOS L=0.13u W=85.7u       ; M device
C341h 3 2 25n                            ; C device
C341i 0 3 8.6m                           ; C device
M341j 3 1 2 0 PMOS L=1.00u W=80.7u
+ AD=51.46p AS=22.64p PD=310.2u PS=214.6u ; M device
R341k 3 1 9.4M                           ; R device
M341l 3 2 1 0 PMOS L=0.50u W=59.1u       ; M device
R341m 3 0 941                            ; R device
C341n 1 0 226p                           ; C device
C341o 0 3 4.4u                           ; C device
C341p 3 2 91n                            ; C device
R341q 0 3 111                            ; R device
C341r 3 1 56n                            ; C device
R341s 3 2 326                            ; R device
C341t 3 1 84n                            ; C device
M341u 1 0 3 2 PMOS L=0.50u W=52.4u AD=45.22p AS=37.49p PD=189.1u PS=177.1u ; M device
C341v 2 3 1.3u                           ; C device
C341w 2 0 88n                            ; C device
M341x 2 3 1 0 PMOS L=0.70u W=76.2u       ; M device
M341y 3 1 2 0 PMOS L=0.35u W=17.2u
+ AD=16.42p AS=19.66p PD=50.7u PS=59.1u ; M device
M341z 1 2 0 3 PMOS L=0.70u W=89.4u AD=16.54p AS=91.06p PD=250.6u PS=190.2u ; M device
C342a 3 2 6.4m                           ; C device
M342b 2 1 0 3 PMOS L=0.18u W=24.6u       ; M device
C342c 1 0 189p                           ; C device
R342d 1 0 186                            ; R device
R342e 2 1 315                            ; R device
M342f 3 0 1 2 PMOS L=0.10u W=41.0u
+ AD=62.57p AS=54.59p PD=83.3u PS=150.5u ; M device
R342g 2 0 210                            ; R device
C342h 2 0 868p                           ; C device
C342i 2 1 5.5m                           ; C device
M342j 1 2 0 3 NMOS L=0.25u W=7.0u AD=12.60p AS=8.29p PD=24.7u PS=27.8u ; M device
R342k 1 3 3k                             ; R device
M342l 2 1 0 3 NMOS L=0.10u W=73.2u
+ AD=27.06p AS=80.49p PD=156.0u PS=169.0u ; M device
M342m 2 0 1 3 NMOS L=0.13u W=69.7u       ; M device
C342n 3 1 65n                            ; C device
C342o 2 1 9.3m                           ; C device
R342p 1 2 65k                            ; R device
R342q 1 3 9.7M                           ; R device
M342r 1 3 2 0 PMOS L=0.10u W=44.5u       ; M device
R342s 3 0 44k                            ; R device
R342t 3 0 1000                           ; R device
R342u 3 2 74k                            ; R device
M342v 1 0 2 3 PMOS L=0.18u W=73.0u       ; M device
C342w 3 2 6.3m                           ; C device
M342x 2 0 3 1 NMOS L=0.35u W=59.5u AD=94.08p AS=71.02p PD=140.0u PS=194.3u ; M device
R342y 0 3 776                            ; R device
M342z 2 0 3 1 NMOS L=0.13u W=22.7u
+ AD=43.62p AS=14.05p PD=57.4u PS=70.4u ; M device
R343a 0 1 208                            ; R device
C343b 2 0 560p                           ; C device
R343c 2 3 80k                            ; R device
M343d 3 0 2 1 PMOS L=0.18u W=47.2u       ; M device
M343e 3 2 1 0 PMOS L=0.50u W=9.6u        ; M device
C343f 2 3 497p                           ; C device
C343g 3 1 684p                           ; C device
R343h 1 2 97                             ; R device
C343i 0 3 80n                            ; C device
M343j 0 3 1 2 PMOS L=0.18u W=48.4u       ; M device
M343k 2 1 3 0 NMOS L=0.10u W=84.0u
+ AD=90.69p AS=166.75p PD=266.7u PS=237.1u ; M device
R343l 2 1 966                            ; R device
M343m 1 3 0 2 PMOS L=0.10u W=63.1u       ; M device
C343n 2 1 64n                            ; C device
C343o 0 3 3.7m                           ; C device
R343p 1 0 6.9M                           ; R device
C343q 2 0 1.2u                           ; C device
R343r 0 2 637                            ; R device
M343s 3 0 2 1 PMOS L=0.70u W=77.9u
+ AD=27.24p AS=17.69p PD=172.2u PS=166.6u ; M device
M343t 1 0 2 3 PMOS L=0.25u W=33.8u       ; M device
C343u 2 1 7.4u                           ; C device
C343v 2 1 4.0u                           ; C device
R343w 1 2 777                            ; R device
R343x 3 2 7.5M                           ; R device
C343y 3 2 4.8m                           ; C device
R343z 3 1 6.5M                           ; R device
M344a 0 2 1 3 PMOS L=0.13u W=50.0u
+ AD=78.80p AS=15.51p PD=166.0u PS=196.4u ; M device
C344b 3 2 9.8u                           ; C device
M344c 0 1 3 2 PMOS L=0.18u W=41.7u       ; M device
R344d 3 2 144                            ; R device
R344e 2 1 8.3M                           ; R device
C344f 3 0 25n                            ; C device
M344g 2 1 3 0 NMOS L=0.25u W=31.1u AD=60.37p AS=11.73p PD=117.0u PS=106.1u ; M device
C344h 3 2 6.3u                           ; C device
M344i 3 0 1 2 PMOS L=0.25u W=60.0u       ; M device
M344j 2 1 0 3 PMOS L=0.18u W=95.0u
+ AD=31.92p AS=13.84p PD=273.2u PS=194.8u ; M device
R344k 0 2 31k                            ; R device
M344l 0 2 3 1 NMOS L=0.50u W=62.6u AD=40.27p AS=23.88p PD=184.5u PS=142.4u ; M device
C344m 1 0 922p                           ; C device
C344n 2 0 5.4m                           ; C device
R344o 3 2 8.8M                           ; R device
R344p 2 3 895                            ; R device
M344q 3 1 2 0 NMOS L=0.18u W=14.4u AD=12.04p AS=9.81p PD=56.8u PS=41.3u ; M device
C344r 0 1 8.6m                           ; C device
C344s 0 1 1n                             ; C device
R344t 3 1 46k                            ; R device
R344u 0 2 7.0M                           ; R device
R344v 2 0 1.3M                           ; R device
M344w 3 0 1 2 PMOS L=0.70u W=93.4u       ; M device
R344x 0 1 475                            ; R device
R344y 1 0 98k                            ; R device
M344z 2 0 1 3 NMOS L=0.50u W=74.9u       ; M device
C345a 3 0 53n                            ; C device
M345b 1 2 0 3 PMOS L=0.13u W=50.7u
+ AD=80.48p AS=41.38p PD=187.9u PS=172.1u ; M device
C345c 2 3 15n                            ; C device
R345d 3 2 87                             ; R device
R345e 3 1 6.1M                           ; R device
M345f 1 0 3 2 PMOS L=0.10u W=95.1u       ; M device
R345g 3 0 158                            ; R device
R345h 2 3 215                            ; R device
M345i 0 2 1 3 PMOS L=0.18u W=64.1u       ; M device
M345j 1 2 3 0 NMOS L=0.50u W=38.3u       ; M device
M345k 2 0 3 1 PMOS L=0.10u W=77.3u       ; M device
R345l 0 3 324                            ; R device
M345m 3 0 1 2 PMOS L=0.10u W=79.5u
+ AD=90.99p AS=105.82p PD=270.4u PS=301.6u ; M device
R345n 1 3 25k                            ; R device
R345o 1 0 587                            ; R device
M345p 1 3 0 2 PMOS L=0.18u W=52.1u       ; M device
M345q 3 1 2 0 PMOS L=0.18u W=21.6u AD=21.72p AS=17.79p PD=68.7u PS=57.4u ; M device
R345r 1 0 737                            ; R device
R345s 0 3 881                            ; R device
R345t 3 2 9.4M                           ; R device
R345u 0 1 676                            ; R device
R345v 3 1 55k                            ; R device
M345w 1 0 3 2 NMOS L=0.70u W=92.7u       ; M device
C345x 2 1 5.9u                           ; C device
C345y 2 3 65n                            ; C device
C345z 2 0 6.6u                           ; C device
M346a 2 3 0 1 NMOS L=1.00u W=27.9u AD=18.36p AS=55.65p PD=62.4u PS=104.4u ; M device
M346b 1 3 0 2 PMOS L=0.70u W=99.9u       ; M device
M346c 1 3 2 0 NMOS L=0.35u W=4.8u
+ AD=2.11p AS=7.34p PD=11.4u PS=18.8u ; M device
R346d 0 3 37k                            ; R device
M346e 2 0 1 3 NMOS L=0.35u W=47.0u       ; M device
M346f 1 2 0 3 PMOS L=0.13u W=64.6u AD=51.66p AS=74.77p PD=256.9u PS=238.3u ; M device
R346g 1 0 28k                            ; R device
M346h 2 1 3 0 PMOS L=0.35u W=58.5u
+ AD=22.39p AS=98.79p PD=148.3u PS=180.2u ; M device
R346i 1 3 343                            ; R device
M346j 1 2 3 0 NMOS L=0.13u W=14.9u AD=19.27p AS=12.07p PD=56.6u PS=34.5u ; M device
M346k 2 3 0 1 NMOS L=0.35u W=30.3u AD=27.36p AS=57.18p PD=110.3u PS=106.0u ; M device
R346l 0 1 8.5M                           ; R device
C346m 2 0 2.9u                           ; C device
C346n 3 1 15n                            ; C device
C346o 3 2 273p                           ; C device
M346p 2 1 3 0 PMOS L=0.25u W=60.1u AD=80.21p AS=23.93p PD=171.1u PS=135.3u ; M device
C346q 1 2 441p                           ; C device
C346r 2 3 9.0m                           ; C device
M346s 3 1 2 0 NMOS L=0.35u W=68.4u       ; M device
C346t 1 0 699p                           ; C device
R346u 1 0 4.3M                           ; R device
R346v 1 3 0.5M                           ; R device
C346w 3 2 9n                             ; C device
C346x 2 1 75n                            ; C device
M346y 3 1 2 0 NMOS L=0.25u W=48.2u
+ AD=37.14p AS=52.68p PD=115.1u PS=176.3u ; M device
M346z 1 3 0 2 NMOS L=0.10u W=30.6u
+ AD=27.09p AS=48.63p PD=115.1u PS=68.7u ; M device
C347a 3 2 333p                           ; C device
M347b 3 0 2 1 PMOS L=0.18u W=41.1u       ; M device
R347c 2 0 496                            ; R device
C347d 1 0 5.2u                           ; C device
R347e 2 0 99k                            ; R device
C347f 2 1 9.9m                           ; C device
C347g 3 2 8.5u                           ; C device
R347h 3 0 603                            ; R device
M347i 2 1 0 3 PMOS L=0.25u W=58.5u       ; M device
C347j 3 0 405p                           ; C device
C347k 2 3 3.0m                           ; C device
M347l 0 1 2 3 PMOS L=0.50u W=75.2u       ; M device
C347m 2 3 707p                           ; C device
C347n 2 3 6.2u                           ; C device
M347o 0 3 2 1 PMOS L=0.10u W=16.5u AD=3.50p AS=22.41p PD=34.5u PS=65.3u ; M device
M347p 0 1 3 2 PMOS L=0.18u W=94.7u       ; M device
R347q 2 0 6.0M                           ; R device
C347r 1 0 90p                            ; C device
C347s 1 2 66n                            ; C device
C347t 2 0 1.5m                           ; C device
C347u 2 1 3.4u                           ; C device
R347v 3 1 2.9M                           ; R device
M347w 3 2 1 0 NMOS L=0.35u W=84.7u       ; M device
R347x 1 2 1.2M                           ; R device
C347y 0 3 3.7u                           ; C device
C347z 3 0 251p                           ; C device
R348a 3 0 58k                            ; R device
M348b 0 3 1 2 PMOS L=0.35u W=27.0u       ; M device
M348c 3 2 0 1 NMOS L=0.18u W=75.2u
+ AD=26.05p AS=29.50p PD=265.7u PS=217.2u ; M device
R348d 1 0 49k                            ; R device
C348e 0 3 4.6m                           ; C device
C348f 3 1 46n                            ; C device
C348g 2 3 435p                           ; C device
R348h 2 3 20                             ; R device
C348i 2 0 8.9m                           ; C device
R348j 1 0 9.9M                           ; R device
M348k 0 3 1 2 PMOS L=0.18u W=39.6u       ; M device
C348l 3 2 467p                           ; C device
C348m 0 2 517p                           ; C device
C348n 0 3 526p                           ; C device
R348o 1 3 185                            ; R device
M348p 2 1 3 0 NMOS L=1.00u W=47.8u AD=53.61p AS=34.40p PD=140.5u PS=160.4u ; M device
C348q 1 3 455p                           ; C device
M348r 3 2 1 0 PMOS L=0.10u W=73.3u
+ AD=111.91p AS=117.22p PD=268.3u PS=223.9u ; M device
C348s 3 0 7.8m                           ; C device
R348t 2 1 1.3M                           ; R device
M348u 2 1 0 3 NMOS L=0.35u W=84.2u       ; M device
C348v 0 2 6.0u                           ; C device
R348w 1 3 655                            ; R device
R348x 2 0 7.4M                           ; R device
R348y 2 0 15k                            ; R device
R348z 2 0 243                            ; R device
M349a 3 0 1 2 NMOS L=0.50u W=77.1u       ; M device
M349b 0 2 1 3 PMOS L=0.50u W=11.9u       ; M device
R349c 2 0 69k                            ; R device
R349d 2 1 955                            ; R device
M349e 3 2 0 1 NMOS L=0.50u W=97.1u       ; M device
R349f 3 2 0.2M                           ; R device
R349g 3 1 0.4M                           ; R device
M349h 0 1 3 2 NMOS L=0.35u W=38.8u
+ AD=5.81p AS=54.50p PD=116.0u PS=88.5u ; M device
R349i 2 1 95k                            ; R device
R349j 3 0 762                            ; R device
C349k 1 3 501p                           ; C device
C349l 2 3 1.6u                           ; C device
R349m 0 2 22k                            ; R device
C349n 3 0 1.9m                           ; C device
M349o 2 3 0 1 NMOS L=0.13u W=31.7u       ; M device
R349p 0 3 2.4M                           ; R device
M349q 1 3 2 0 NMOS L=0.35u W=26.1u
+ AD=23.22p AS=17.62p PD=84.6u PS=82.0u ; M device
M349r 0 1 3 2 NMOS L=0.18u W=43.6u       ; M device
R349s 1 0 97k                            ; R device
R349t 0 2 5.7M                           ; R device
M349u 2 1 3 0 NMOS L=0.50u W=64.1u       ; M device
M349v 1 2 3 0 NMOS L=1.00u W=33.6u AD=8.09p AS=8.09p PD=110.8u PS=69.2u ; M device
C349w 3 2 933p                           ; C device
C349x 1 2 62n                            ; C device
C349y 0 1 6.5u                           ; C device
M349z 3 1 2 0 PMOS L=0.13u W=5.2u AD=4.04p AS=9.52p PD=15.8u PS=13.3u ; M device
C350a 2 0 1.1u                           ; C device
R350b 0 1 941                            ; R device
M350c 1 2 0 3 PMOS L=1.00u W=2.0u        ; M device
M350d 3 1 2 0 PMOS L=0.70u W=71.7u       ; M device
M350e 0 1 2 3 PMOS L=0.70u W=26.8u       ; M device
R350f 1 2 0.8M                           ; R device
M350g 2 3 1 0 PMOS L=0.25u W=13.3u
+ AD=17.05p AS=3.24p PD=36.9u PS=36.4u ; M device
R350h 0 2 8.5M                           ; R device
C350i 0 3 84n                            ; C device
C350j 0 1 747p                           ; C device
R350k 1 2 24k                            ; R device
M350l 1 2 3 0 PMOS L=0.10u W=59.7u       ; M device
M350m 0 1 3 2 PMOS L=0.18u W=95.6u       ; M device
C350n 1 3 571p                           ; C device
M350o 3 2 0 1 NMOS L=0.18u W=87.3u       ; M device
C350p 3 0 7.7u                           ; C device
R350q 3 2 42k                            ; R device
C350r 3 0 3.0m                           ; C device
R350s 0 3 7.2M                           ; R device
R350t 2 3 7.2M                           ; R device
C350u 1 0 877p                           ; C device
R350v 0 2 9.7M                           ; R device
M350w 3 2 1 0 PMOS L=0.10u W=85.3u
+ AD=55.67p AS=77.50p PD=319.8u PS=325.0u ; M device
R350x 2 3 3.1M                           ; R device
C350y 0 1 3.4m                           ; C device
R350z 2 0 412                            ; R device
C351a 1 2 28n                            ; C device
C351b 0 3 6.0u                           ; C device
M351c 1 0 2 3 PMOS L=0.35u W=91.7u AD=157.73p AS=137.55p PD=217.8u PS=300.6u ; M device
C351d 3 2 4.8m                           ; C device
C351e 3 2 688p                           ; C device
C351f 3 2 18n                            ; C device
R351g 2 3 75k                            ; R device
M351h 0 3 2 1 PMOS L=0.10u W=66.0u AD=68.05p AS=71.05p PD=158.1u PS=233.9u ; M device
C351i 2 3 410p                           ; C device
M351j 3 1 2 0 PMOS L=0.50u W=12.9u
+ AD=20.00p AS=5.38p PD=47.5u PS=34.5u ; M device
R351k 3 2 2.7M                           ; R device
R351l 1 3 862                            ; R device
R351m 2 0 806                            ; R device
M351n 3 2 0 1 NMOS L=0.35u W=45.0u
+ AD=6.73p AS=20.02p PD=172.9u PS=153.2u ; M device
M351o 0 1 3 2 PMOS L=0.70u W=51.3u
+ AD=6.51p AS=99.71p PD=187.5u PS=136.7u ; M device
C351p 3 2 62n                            ; C device
C351q 0 2 0.4u                           ; C device
C351r 0 2 3.5m                           ; C device
M351s 2 3 0 1 PMOS L=0.13u W=39.6u       ; M device
R351t 1 2 8.9M                           ; R device
M351u 3 0 2 1 PMOS L=0.35u W=39.1u       ; M device
C351v 1 0 86p                            ; C device
M351w 1 0 3 2 PMOS L=0.70u W=44.7u       ; M device
R351x 1 3 772                            ; R device
M351y 2 3 1 0 PMOS L=0.50u W=20.5u AD=25.11p AS=24.23p PD=75.2u PS=48.3u ; M device
C351z 0 3 5.9m                           ; C device
C352a 1 2 8.3m                           ; C device
R352b 1 2 817                            ; R device
M352c 1 2 3 0 NMOS L=0.13u W=16.6u       ; M device
R352d 0 2 43k                            ; R device
M352e 0 2 1 3 NMOS L=0.10u W=32.8u       ; M device
M352f 3 1 0 2 PMOS L=1.00u W=18.0u       ; M device
C352g 3 2 0.6m                           ; C device
M352h 0 1 3 2 NMOS L=0.18u W=61.2u
+ AD=22.22p AS=110.00p PD=136.0u PS=133.2u ; M device
C352i 1 0 252p                           ; C device
C352j 0 2 12n                            ; C device
M352k 1 3 2 0 NMOS L=0.35u W=64.6u       ; M device
M352l 3 2 0 1 PMOS L=0.13u W=43.9u AD=78.82p AS=67.43p PD=165.0u PS=97.1u ; M device
R352m 2 1 774                            ; R device
C352n 1 2 8.3u                           ; C device
C352o 0 1 667p                           ; C device
M352p 2 1 3 0 NMOS L=0.18u W=66.6u AD=15.74p AS=55.34p PD=196.3u PS=223.4u ; M device
R352q 0 2 8.2M                           ; R device
C352r 3 0 6.1u                           ; C device
M352s 0 2 3 1 NMOS L=0.18u W=13.8u
+ AD=15.89p AS=27.46p PD=49.3u PS=40.6u ; M device
R352t 1 2 8.1M                           ; R device
C352u 0 2 8.8u                           ; C device
R352v 1 3 7.7M                           ; R device
M352w 3 2 0 1 PMOS L=0.70u W=5.5u        ; M device
M352x 0 1 2 3 PMOS L=0.10u W=69.5u
+ AD=34.42p AS=98.80p PD=165.0u PS=197.5u ; M device
C352y 2 1 10n                            ; C device
M352z 3 0 2 1 NMOS L=0.10u W=30.1u AD=41.34p AS=45.75p PD=102.3u PS=101.9u ; M device
C353a 3 0 108p                           ; C device
R353b 2 1 4                              ; R device
R353c 1 0 7.1M                           ; R device
M353d 3 0 1 2 PMOS L=0.70u W=20.2u       ; M device
R353e 3 1 26k                            ; R device
M353f 1 2 3 0 PMOS L=0.25u W=33.5u       ; M device
R353g 2 3 2.7M                           ; R device
M353h 0 3 1 2 PMOS L=0.50u W=95.9u       ; M device
M353i 0 1 2 3 PMOS L=0.25u W=40.8u AD=6.40p AS=51.93p PD=110.2u PS=106.9u ; M device
M353j 0 3 2 1 PMOS L=0.50u W=72.4u
+ AD=135.29p AS=55.04p PD=271.4u PS=196.4u ; M device
M353k 1 3 2 0 PMOS L=0.10u W=98.5u
+ AD=116.37p AS=128.06p PD=312.5u PS=283.8u ; M device
C353l 3 2 385p                           ; C device
M353m 3 1 0 2 PMOS L=0.10u W=86.8u AD=54.71p AS=87.06p PD=206.2u PS=252.6u ; M device
R353n 0 1 6.5M                           ; R device
R353o 0 2 831                            ; R device
C353p 3 0 7.2m                           ; C device
C353q 1 3 175p                           ; C device
C353r 1 3 361p                           ; C device
C353s 1 0 494p                           ; C device
C353t 1 0 2.7u                           ; C device
R353u 1 0 916                            ; R device
M353v 1 2 0 3 PMOS L=0.25u W=68.6u AD=133.20p AS=49.37p PD=254.0u PS=198.5u ; M device
M353w 0 1 3 2 NMOS L=0.10u W=79.1u
+ AD=73.10p AS=79.77p PD=267.8u PS=191.6u ; M device
M353x 3 0 1 2 PMOS L=0.70u W=41.4u       ; M device
R353y 0 2 7.8M                           ; R device
R353z 3 0 8.0M                           ; R device
M354a 0 2 3 1 PMOS L=0.10u W=70.9u       ; M device
R354b 1 3 71k                            ; R device
C354c 3 1 88n                            ; C device
C354d 0 2 8.6u                           ; C device
C354e 2 3 3.2m                           ; C device
R354f 3 1 41k                            ; R device
R354g 0 2 642                            ; R device
M354h 0 3 2 1 PMOS L=0.18u W=39.6u       ; M device
R354i 1 3 18k                            ; R device
R354j 3 1 3.6M                           ; R device
M354k 3 1 2 0 NMOS L=0.13u W=93.9u
+ AD=155.71p AS=39.88p PD=246.2u PS=196.3u ; M device
C354l 3 0 4.1m                           ; C device
R354m 1 2 920                            ; R device
R354n 0 1 459                            ; R device
M354o 0 2 1 3 PMOS L=0.50u W=62.5u       ; M device
M354p 2 1 0 3 PMOS L=0.50u W=0.6u        ; M device
R354q 3 2 104                            ; R device
C354r 3 2 6.7u                           ; C device
C354s 1 0 4.2u                           ; C device
R354t 3 1 23k                            ; R device
M354u 2 3 0 1 PMOS L=0.70u W=88.7u AD=150.39p AS=38.51p PD=234.1u PS=245.5u ; M device
M354v 0 1 3 2 NMOS L=1.00u W=78.1u       ; M device
C354w 3 0 7.9u                           ; C device
R354x 3 1 67k                            ; R device
M354y 1 2 0 3 PMOS L=0.18u W=29.0u       ; M device
R354z 0 1 2.9M                           ; R device
M355a 0 1 3 2 NMOS L=0.50u W=11.1u
+ AD=10.93p AS=9.53p PD=24.5u PS=22.5u ; M device
C355b 3 2 95p                            ; C device
M355c 0 3 1 2 PMOS L=1.00u W=54.4u       ; M device
C355d 2 3 42n                            ; C device
C355e 0 3 6.6u                           ; C device
M355f 3 1 2 0 PMOS L=1.00u W=47.8u AD=67.25p AS=84.24p PD=95.9u PS=186.8u ; M device
M355g 3 0 2 1 PMOS L=0.35u W=88.5u       ; M device
M355h 0 3 1 2 PMOS L=0.13u W=93.9u       ; M device
R355i 3 2 0.6M                           ; R device
R355j 1 3 25k                            ; R device
R355k 0 1 34k                            ; R device
C355l 3 1 632p                           ; C device
M355m 1 2 0 3 PMOS L=0.70u W=41.5u       ; M device
R355n 0 2 9.9M                           ; R device
R355o 3 0 1.7M                           ; R device
R355p 1 3 8.7M                           ; R device
M355q 2 0 3 1 NMOS L=0.50u W=85.8u       ; M device
C355r 1 2 40p                            ; C device
R355s 1 0 29k                            ; R device
R355t 2 0 6.5M                           ; R device
M355u 1 2 0 3 PMOS L=1.00u W=97.3u
+ AD=34.39p AS=88.95p PD=247.3u PS=269.5u ; M device
M355v 1 0 3 2 PMOS L=0.70u W=42.9u       ; M device
M355w 1 3 0 2 NMOS L=1.00u W=38.2u
+ AD=8.23p AS=73.47p PD=86.9u PS=131.4u ; M device
M355x 1 2 3 0 PMOS L=0.10u W=35.0u
+ AD=29.97p AS=40.68p PD=88.5u PS=112.4u ; M device
R355y 1 0 42k                            ; R device
C355z 2 3 1.4m                           ; C device
R356a 3 1 7.8M                           ; R device
C356b 2 3 85p                            ; C device
C356c 2 0 2.4u                           ; C device
C356d 2 1 6.0m                           ; C device
C356e 0 2 4.7u                           ; C device
R356f 0 2 15k                            ; R device
M356g 2 3 1 0 NMOS L=0.25u W=43.3u       ; M device
R356h 3 2 47k                            ; R device
R356i 2 0 239                            ; R device
R356j 3 0 49k                            ; R device
C356k 2 0 35n                            ; C device
M356l 1 3 2 0 NMOS L=0.70u W=17.5u AD=19.10p AS=14.05p PD=53.0u PS=64.6u ; M device
C356m 2 0 4.5m                           ; C device
R356n 1 2 399                            ; R device
M356o 0 1 3 2 NMOS L=1.00u W=77.7u       ; M device
M356p 1 0 2 3 NMOS L=0.70u W=66.6u       ; M device
M356q 2 1 0 3 PMOS L=0.18u W=44.2u
+ AD=62.49p AS=71.78p PD=105.0u PS=156.3u ; M device
M356r 0 1 3 2 PMOS L=0.70u W=20.6u       ; M device
C356s 3 2 45n                            ; C device
C356t 1 2 7.8u                           ; C device
R356u 2 3 851                            ; R device
R356v 2 3 5.0M                           ; R device
C356w 0 2 2.7m                           ; C device
M356x 0 2 3 1 NMOS L=1.00u W=47.5u AD=78.70p AS=50.87p PD=122.3u PS=179.5u ; M device
C356y 0 1 9.9m                           ; C device
R356z 0 1 8.9M                           ; R device
M357a 2 1 3 0 PMOS L=0.25u W=79.4u AD=145.55p AS=88.10p PD=302.8u PS=215.2u ; M device
R357b 2 1 59k                            ; R device
M357c 2 0 1 3 PMOS L=0.10u W=9.1u AD=14.76p AS=13.01p PD=34.3u PS=24.6u ; M device
R357d 0 3 841                            ; R device
C357e 3 1 796p                           ; C device
C357f 3 0 3.7m                           ; C device
C357g 0 3 243p                           ; C device
M357h 2 0 3 1 PMOS L=0.35u W=67.2u       ; M device
M357i 3 1 0 2 NMOS L=0.18u W=24.1u       ; M device
C357j 2 1 5.4m                           ; C device
M357k 3 0 2 1 PMOS L=0.70u W=10.4u       ; M device
C357l 0 3 719p                           ; C device
M357m 3 1 2 0 PMOS L=0.18u W=45.3u AD=44.28p AS=27.84p PD=158.3u PS=176.7u ; M device
R357n 1 3 22                             ; R device
C357o 2 3 32n                            ; C device
C357p 0 1 0.7u                           ; C device
R357q 1 3 0.6M                           ; R device
C357r 2 1 57n                            ; C device
R357s 3 0 9.3M                           ; R device
C357t 3 0 36n                            ; C device
M357u 2 1 3 0 PMOS L=0.70u W=96.2u AD=179.71p AS=157.50p PD=327.4u PS=356.5u ; M device
M357v 1 2 3 0 PMOS L=1.00u W=97.5u       ; M device
M357w 2 0 1 3 NMOS L=0.70u W=86.0u       ; M device
M357x 2 1 0 3 NMOS L=0.10u W=16.0u
+ AD=7.17p AS=3.36p PD=52.9u PS=42.8u ; M device
R357y 1 0 7k                             ; R device
C357z 2 3 7.9m                           ; C device
C358a 3 1 5.2m                           ; C device
R358b 1 0 713                            ; R device
C358c 0 3 9.3m                           ; C device
C358d 1 3 5.5m                           ; C device
M358e 1 3 0 2 PMOS L=1.00u W=80.9u       ; M device
M358f 0 2 3 1 NMOS L=0.70u W=81.1u AD=108.47p AS=10.23p PD=187.8u PS=313.7u ; M device
M358g 1 2 3 0 PMOS L=0.35u W=62.3u       ; M device
M358h 3 2 1 0 NMOS L=0.35u W=51.8u       ; M device
C358i 0 1 94n                            ; C device
C358j 1 0 2.0u                           ; C device
M358k 1 2 3 0 PMOS L=0.18u W=10.7u AD=7.35p AS=4.78p PD=28.4u PS=23.8u ; M device
M358l 2 3 1 0 NMOS L=0.70u W=40.1u       ; M device
M358m 2 1 0 3 NMOS L=0.10u W=67.6u       ; M device
R358n 2 0 108                            ; R device
C358o 1 0 9.8u                           ; C device
C358p 1 3 368p                           ; C device
C358q 3 0 77n                            ; C device
R358r 1 0 86k                            ; R device
C358s 0 3 690p                           ; C device
R358t 2 1 5.9M                           ; R device
C358u 0 1 2.4m                           ; C device
R358v 3 0 419                            ; R device
M358w 0 1 2 3 NMOS L=0.50u W=24.6u AD=7.49p AS=13.43p PD=95.5u PS=91.6u ; M device
M358x 2 3 1 0 PMOS L=0.35u W=39.7u AD=65.48p AS=5.90p PD=119.7u PS=99.3u ; M device
C358y 2 3 0.4u                           ; C device
R358z 2 0 180                            ; R device
M359a 3 0 1 2 PMOS L=1.00u W=30.5u       ; M device
M359b 2 1 0 3 NMOS L=0.35u W=49.9u
+ AD=20.35p AS=33.72p PD=162.2u PS=138.4u ; M device
C359c 1 2 8.3m                           ; C device
C359d 1 2 2.9m                           ; C device
R359e 2 1 9.7M                           ; R device
C359f 2 0 47n                            ; C device
M359g 1 2 3 0 NMOS L=0.13u W=20.6u
+ AD=32.26p AS=11.66p PD=59.8u PS=43.2u ; M device
R359h 1 2 31k                            ; R device
R359i 3 0 17k                            ; R device
R359j 2 3 7.0M                           ; R device
R359k 2 0 10.0M                          ; R device
M359l 2 0 3 1 NMOS L=0.70u W=8.5u        ; M device
R359m 2 3 0.7M                           ; R device
R359n 3 1 336                            ; R device
R359o 1 2 6.3M                           ; R device
R359p 3 2 354                            ; R device
R359q 3 1 79k                            ; R device
R359r 2 1 2.4M                           ; R device
R359s 2 3 9.6M                           ; R device
C359t 2 3 5.4m                           ; C device
R359u 3 2 3.2M                           ; R device
R359v 0 2 8.1M                           ; R device
C359w 0 2 2.5u                           ; C device
R359x 2 1 8.6M                           ; R device
R359y 3 0 49k                            ; R device
C359z 0 2 7.5m                           ; C device
M360a 3 1 2 0 NMOS L=0.70u W=8.5u AD=5.79p AS=9.23p PD=33.0u PS=33.7u ; M device
C360b 1 3 92n                            ; C device
M360c 1 3 0 2 NMOS L=1.00u W=50.8u       ; M device
M360d 0 3 1 2 PMOS L=0.13u W=99.6u       ; M device
C360e 3 0 10n                            ; C device
R360f 0 3 100k                           ; R device
M360g 3 2 1 0 NMOS L=0.10u W=98.6u       ; M device
R360h 2 1 597                            ; R device
R360i 0 3 246                            ; R device
C360j 1 0 89n                            ; C device
C360k 1 0 1.7u                           ; C device
R360l 3 2 112                            ; R device
M360m 2 3 0 1 PMOS L=0.70u W=35.1u
+ AD=8.57p AS=24.67p PD=128.7u PS=119.3u ; M device
R360n 0 1 626                            ; R device
C360o 0 3 302p                           ; C device
R360p 3 0 8.3M                           ; R device
R360q 2 1 8.8M                           ; R device
C360r 0 3 5.8u                           ; C device
R360s 1 3 9.8M                           ; R device
R360t 2 3 0.3M                           ; R device
M360u 3 1 0 2 PMOS L=0.25u W=99.1u
+ AD=192.17p AS=196.55p PD=316.3u PS=355.2u ; M device
R360v 2 0 71k                            ; R device
R360w 0 3 733                            ; R device
C360x 0 2 87n                            ; C device
M360y 0 3 2 1 NMOS L=0.13u W=22.2u AD=13.60p AS=19.92p PD=46.5u PS=52.0u ; M device
C360z 0 2 70n                            ; C device
R361a 1 0 219                            ; R device
R361b 2 1 28k                            ; R device
R361c 3 0 7.3M                           ; R device
M361d 1 2 3 0 NMOS L=0.50u W=95.3u       ; M device
R361e 0 2 9.0M                           ; R device
M361f 3 2 0 1 PMOS L=0.25u W=99.5u       ; M device
M361g 3 0 1 2 NMOS L=0.10u W=19.0u AD=10.49p AS=29.61p PD=51.8u PS=38.7u ; M device
C361h 0 1 738p                           ; C device
R361i 2 1 8.7M                           ; R device
R361j 1 0 919                            ; R device
M361k 2 3 0 1 PMOS L=1.00u W=83.5u       ; M device
R361l 0 2 751                            ; R device
M361m 1 0 2 3 PMOS L=0.70u W=88.2u
+ AD=173.32p AS=146.41p PD=228.6u PS=334.7u ; M device
C361n 2 1 805p                           ; C device
R361o 3 1 895                            ; R device
C361p 0 2 7.2u                           ; C device
R361q 1 3 43k                            ; R device
R361r 3 1 934                            ; R device
R361s 0 2 34k                            ; R device
R361t 1 3 974                            ; R device
R361u 1 2 0.4M                           ; R device
M361v 0 2 3 1 NMOS L=0.35u W=81.0u
+ AD=136.03p AS=83.59p PD=163.6u PS=263.6u ; M device
R361w 3 2 161                            ; R device
M361x 3 1 2 0 NMOS L=0.70u W=57.6u
+ AD=64.94p AS=90.68p PD=203.7u PS=217.2u ; M device
M361y 3 0 2 1 NMOS L=0.35u W=59.5u
+ AD=18.84p AS=56.11p PD=147.6u PS=125.0u ; M device
C361z 2 1 0.2u                           ; C device
C362a 1 0 30n                            ; C device
C362b 1 0 5.9u                           ; C device
R362c 2 0 478                            ; R device
M362d 1 2 0 3 NMOS L=0.18u W=45.0u AD=18.73p AS=80.09p PD=146.7u PS=168.1u ; M device
C362e 1 3 961p                           ; C device
C362f 1 2 2.9m                           ; C device
C362g 2 3 4.6u                           ; C device
C362h 2 1 237p                           ; C device
R362i 2 0 20k                            ; R device
M362j 0 2 1 3 PMOS L=0.10u W=24.4u       ; M device
M362k 3 0 1 2 PMOS L=0.10u W=14.8u
+ AD=10.59p AS=6.09p PD=31.2u PS=45.0u ; M device
C362l 1 2 9.6u                           ; C device
M362m 3 2 0 1 PMOS L=0.50u W=43.0u
+ AD=10.02p AS=79.98p PD=132.4u PS=88.6u ; M device
R362n 2 3 11k                            ; R device
M362o 0 1 3 2 NMOS L=0.25u W=6.1u        ; M device
C362p 2 3 8.8u                           ; C device
M362q 0 2 3 1 PMOS L=0.25u W=41.5u
+ AD=40.66p AS=40.52p PD=126.1u PS=128.0u ; M device
M362r 0 3 2 1 NMOS L=0.10u W=17.0u
+ AD=1.76p AS=25.65p PD=58.0u PS=64.5u ; M device
C362s 2 1 1.0m                           ; C device
R362t 3 0 22k                            ; R device
M362u 3 1 0 2 NMOS L=0.13u W=51.7u       ; M device
C362v 0 3 472p                           ; C device
C362w 0 2 1.7m                           ; C device
R362x 1 3 53k                            ; R device
R362y 1 2 25k                            ; R device
R362z 1 2 650                            ; R device
M363a 0 1 3 2 NMOS L=0.10u W=60.3u AD=9.83p AS=87.55p PD=142.6u PS=167.2u ; M device
C363b 1 3 2.2u                           ; C device
C363c 1 2 7.2m                           ; C device
M363d 3 0 2 1 NMOS L=0.18u W=14.2u AD=21.65p AS=4.53p PD=56.6u PS=44.7u ; M device
C363e 0 2 80n                            ; C device
C363f 3 1 946p                           ; C device
C363g 3 1 9.0m                           ; C device
C363h 0 2 7.8m                           ; C device
R363i 2 0 291                            ; R device
C363j 2 3 7.6m                           ; C device
M363k 3 1 2 0 PMOS L=0.35u W=27.1u       ; M device
M363l 2 1 3 0 PMOS L=0.18u W=80.2u       ; M device
M363m 2 1 3 0 NMOS L=0.25u W=23.3u
+ AD=23.06p AS=42.57p PD=74.7u PS=72.6u ; M device
C363n 1 3 667p                           ; C device
M363o 0 3 1 2 PMOS L=1.00u W=48.0u
+ AD=61.05p AS=31.68p PD=176.5u PS=156.9u ; M device
M363p 1 3 2 0 PMOS L=0.25u W=64.6u
+ AD=18.32p AS=128.56p PD=248.4u PS=176.2u ; M device
C363q 0 1 539p                           ; C device
M363r 1 2 3 0 NMOS L=0.35u W=77.9u       ; M device
C363s 3 1 6.7m                           ; C device
C363t 3 1 8.2u                           ; C device
M363u 0 1 2 3 PMOS L=0.10u W=59.3u
+ AD=55.44p AS=5.98p PD=160.5u PS=154.8u ; M device
R363v 1 3 43k                            ; R device
C363w 3 2 3.4u                           ; C device
R363x 0 2 863                            ; R device
M363y 3 0 1 2 PMOS L=0.70u W=95.7u AD=163.42p AS=72.73p PD=349.5u PS=241.4u ; M device
M363z 2 3 1 0 PMOS L=0.35u W=16.9u
+ AD=16.52p AS=6.86p PD=54.0u PS=60.5u ; M device
C364a 0 1 4n                             ; C device
C364b 1 3 4.1m                           ; C device
M364c 3 0 2 1 PMOS L=0.18u W=14.8u AD=19.84p AS=11.27p PD=36.0u PS=32.3u ; M device
C364d 1 2 0.9u                           ; C device
R364e 1 3 4.4M                           ; R device
C364f 0 2 1n                             ; C device
C364g 2 0 1.3m                           ; C device
M364h 3 1 0 2 PMOS L=0.70u W=1.6u
+ AD=2.48p AS=0.89p PD=4.3u PS=4.7u ; M device
M364i 0 3 2 1 NMOS L=0.50u W=26.3u
+ AD=38.48p AS=40.98p PD=100.5u PS=91.8u ; M device
C364j 3 1 9.1m                           ; C device
C364k 0 1 71n                            ; C device
M364l 0 2 1 3 PMOS L=0.10u W=13.7u       ; M device
M364m 3 1 2 0 PMOS L=0.18u W=19.6u       ; M device
R364n 0 1 1.8M                           ; R device
C364o 2 3 1.0m                           ; C device
R364p 2 1 78k                            ; R device
M364q 3 1 2 0 PMOS L=0.35u W=10.2u AD=3.03p AS=18.30p PD=38.9u PS=37.9u ; M device
C364r 3 1 70n                            ; C device
R364s 0 1 12k                            ; R device
M364t 2 3 0 1 NMOS L=0.35u W=84.3u       ; M device
M364u 1 2 0 3 PMOS L=0.10u W=11.9u
+ AD=17.32p AS=3.12p PD=44.4u PS=45.9u ; M device
M364v 3 2 1 0 PMOS L=0.35u W=52.5u AD=21.45p AS=8.82p PD=164.5u PS=167.4u ; M device
M364w 0 2 1 3 PMOS L=0.70u W=31.4u AD=19.14p AS=5.32p PD=92.7u PS=114.0u ; M device
M364x 0 2 1 3 NMOS L=0.10u W=12.3u AD=12.07p AS=18.18p PD=34.8u PS=36.4u ; M device
C364y 1 0 455p                           ; C device
R364z 0 2 281                            ; R device
C365a 3 1 8.0u                           ; C device
C365b 1 0 7.8m                           ; C device
M365c 2 1 3 0 PMOS L=0.13u W=59.6u
+ AD=25.26p AS=7.22p PD=171.9u PS=193.4u ; M device
R365d 1 3 88k                            ; R device
C365e 1 2 482p                           ; C device
M365f 0 1 3 2 PMOS L=0.10u W=46.3u
+ AD=48.06p AS=88.96p PD=102.8u PS=123.5u ; M device
M365g 2 1 3 0 NMOS L=0.35u W=77.2u AD=44.48p AS=55.10p PD=245.3u PS=235.3u ; M device
R365h 0 3 9.0M                           ; R device
C365i 2 1 61n                            ; C device
M365j 2 3 0 1 NMOS L=0.35u W=25.5u AD=22.91p AS=49.23p PD=87.6u PS=90.6u ; M device
R365k 3 2 1.2M                           ; R device
R365l 3 1 5.2M                           ; R device
R365m 3 0 65k                            ; R device
R365n 3 1 12k                            ; R device
C365o 1 2 531p                           ; C device
M365p 2 1 0 3 NMOS L=0.35u W=16.0u
+ AD=7.54p AS=17.37p PD=36.9u PS=41.8u ; M device
C365q 2 0 9.4u                           ; C device
M365r 3 0 1 2 PMOS L=1.00u W=78.6u
+ AD=52.03p AS=122.23p PD=198.5u PS=262.1u ; M device
M365s 0 2 1 3 NMOS L=0.13u W=41.4u       ; M device
R365t 0 1 601                            ; R device
M365u 3 2 1 0 NMOS L=0.50u W=30.0u AD=57.03p AS=14.51p PD=103.9u PS=108.6u ; M device
C365v 0 1 6.0u                           ; C device
M365w 0 3 1 2 PMOS L=0.35u W=93.2u
+ AD=133.22p AS=154.86p PD=264.8u PS=321.4u ; M device
M365x 2 1 0 3 PMOS L=0.35u W=22.3u AD=9.80p AS=7.78p PD=57.2u PS=75.8u ; M device
C365y 3 0 9.7u                           ; C device
C365z 2 1 789p                           ; C device
M366a 2 1 3 0 PMOS L=0.70u W=65.8u       ; M device
M366b 2 1 0 3 NMOS L=0.35u W=85.5u       ; M device
M366c 3 0 2 1 NMOS L=0.25u W=78.4u       ; M device
M366d 2 1 0 3 PMOS L=0.50u W=14.9u AD=5.00p AS=18.76p PD=48.1u PS=40.5u ; M device
M366e 3 0 2 1 NMOS L=0.35u W=54.6u       ; M device
C366f 1 3 884p                           ; C device
R366g 0 1 40k                            ; R device
R366h 2 3 13k                            ; R device
M366i 2 0 3 1 PMOS L=0.25u W=88.5u AD=132.23p AS=132.11p PD=205.5u PS=307.7u ; M device
M366j 2 1 3 0 PMOS L=0.25u W=5.0u AD=7.73p AS=3.74p PD=14.3u PS=20.0u ; M device
C366k 3 1 917p                           ; C device
M366l 3 1 2 0 NMOS L=0.13u W=22.2u
+ AD=5.08p AS=30.55p PD=63.2u PS=70.7u ; M device
C366m 1 0 325p                           ; C device
R366n 2 3 0.4M                           ; R device
M366o 1 2 3 0 NMOS L=0.25u W=99.9u       ; M device
R366p 3 0 93k                            ; R device
R366q 2 0 48k                            ; R device
M366r 3 2 0 1 NMOS L=0.50u W=22.0u
+ AD=31.75p AS=3.56p PD=76.8u PS=82.0u ; M device
C366s 0 3 86n                            ; C device
C366t 3 1 8.4m                           ; C device
M366u 2 3 0 1 PMOS L=0.13u W=75.4u AD=69.24p AS=42.11p PD=269.2u PS=293.1u ; M device
M366v 0 3 1 2 NMOS L=0.25u W=46.4u
+ AD=84.09p AS=48.52p PD=126.3u PS=146.6u ; M device
C366w 3 2 321p                           ; C device
M366x 3 0 2 1 NMOS L=0.35u W=2.7u AD=5.18p AS=4.22p PD=7.9u PS=6.4u ; M device
R366y 1 3 56k                            ; R device
C366z 0 1 100n                           ; C device
C367a 0 1 246p                           ; C device
M367b 1 0 2 3 PMOS L=0.25u W=68.8u       ; M device
R367c 3 2 7.0M                           ; R device
R367d 3 1 92k                            ; R device
R367e 2 1 58k                            ; R device
M367f 2 0 1 3 PMOS L=0.25u W=82.7u AD=57.74p AS=40.95p PD=191.2u PS=177.3u ; M device
C367g 2 1 9.3u                           ; C device
R367h 1 2 8.6M                           ; R device
R367i 3 0 831                            ; R device
M367j 1 0 3 2 PMOS L=0.10u W=80.7u       ; M device
R367k 0 2 26k                            ; R device
R367l 2 3 376                            ; R device
C367m 1 3 17n                            ; C device
M367n 1 2 0 3 NMOS L=0.35u W=72.9u
+ AD=21.33p AS=122.36p PD=256.9u PS=240.6u ; M device
C367o 1 2 98n                            ; C device
C367p 2 3 2.9u                           ; C device
C367q 3 0 2.7u                           ; C device
M367r 3 1 0 2 NMOS L=0.13u W=27.8u       ; M device
R367s 1 0 40k                            ; R device
R367t 3 1 66k                            ; R device
M367u 1 2 0 3 PMOS L=0.50u W=88.8u
+ AD=143.27p AS=53.57p PD=287.4u PS=284.7u ; M device
M367v 1 2 3 0 NMOS L=1.00u W=81.8u
+ AD=20.89p AS=63.83p PD=253.6u PS=243.7u ; M device
R367w 3 2 30k                            ; R device
R367x 2 1 341                            ; R device
M367y 2 3 1 0 NMOS L=0.10u W=40.4u
+ AD=76.82p AS=48.91p PD=142.6u PS=89.6u ; M device
M367z 2 3 1 0 NMOS L=0.13u W=78.2u AD=94.78p AS=95.18p PD=176.6u PS=237.7u ; M device
R368a 2 1 8.1M                           ; R device
M368b 3 0 1 2 NMOS L=1.00u W=71.3u       ; M device
C368c 0 2 0.4u                           ; C device
C368d 1 3 9.6u                           ; C device
R368e 2 0 851                            ; R device
R368f 3 1 88k                            ; R device
M368g 1 3 2 0 NMOS L=0.25u W=90.6u       ; M device
M368h 2 0 3 1 NMOS L=0.13u W=33.9u       ; M device
R368i 1 2 866                            ; R device
M368j 3 1 0 2 PMOS L=0.70u W=49.3u
+ AD=37.71p AS=44.48p PD=154.7u PS=122.9u ; M device
R368k 0 2 54k                            ; R device
R368l 0 2 70k                            ; R device
C368m 3 0 946p                           ; C device
C368n 1 0 68n                            ; C device
R368o 0 2 907                            ; R device
C368p 3 0 6.0u                           ; C device
M368q 1 0 2 3 NMOS L=0.13u W=66.5u AD=30.07p AS=89.30p PD=221.4u PS=151.8u ; M device
C368r 2 1 54n                            ; C device
R368s 1 2 0.6M                           ; R device
C368t 1 0 5n                             ; C device
M368u 0 3 2 1 NMOS L=1.00u W=42.1u       ; M device
M368v 0 3 2 1 PMOS L=1.00u W=51.1u AD=53.55p AS=35.14p PD=165.1u PS=204.4u ; M device
C368w 0 3 0.7u                           ; C device
R368x 2 0 9.5M                           ; R device
C368y 0 2 7.0u                           ; C device
C368z 1 0 816p                           ; C device
C369a 0 1 0.4u                           ; C device
R369b 1 0 8.3M                           ; R device
R369c 2 3 436                            ; R device
R369d 1 2 4.0M                           ; R device
R369e 1 0 3k                             ; R device
C369f 2 0 108p                           ; C device
M369g 2 0 1 3 NMOS L=0.10u W=99.7u AD=63.99p AS=193.55p PD=234.1u PS=201.2u ; M device
R369h 1 2 1.2M                           ; R device
R369i 3 0 62k                            ; R device
C369j 1 3 527p                           ; C device
M369k 0 2 3 1 NMOS L=0.25u W=28.8u AD=18.29p AS=32.54p PD=102.5u PS=65.5u ; M device
M369l 0 3 2 1 NMOS L=0.70u W=50.9u AD=32.25p AS=42.00p PD=144.6u PS=193.3u ; M device
C369m 3 0 40n                            ; C device
R369n 1 0 6.7M                           ; R device
R369o 3 0 248                            ; R device
C369p 0 1 9.3m                           ; C device
R369q 1 2 84k                            ; R device
M369r 2 3 0 1 PMOS L=0.18u W=38.8u       ; M device
C369s 1 2 9.4u                           ; C device
R369t 1 3 0.3M                           ; R device
C369u 3 0 2.4m                           ; C device
R369v 1 0 3.4M                           ; R device
C369w 2 1 3.7m                           ; C device
R369x 3 2 902                            ; R device
M369y 2 1 3 0 NMOS L=0.50u W=47.4u
+ AD=12.40p AS=75.08p PD=159.0u PS=113.7u ; M device
R369z 1 3 852                            ; R device
M370a 3 0 1 2 PMOS L=0.50u W=30.1u AD=21.16p AS=19.08p PD=110.4u PS=96.4u ; M device
M370b 1 3 2 0 PMOS L=0.35u W=45.4u AD=6.31p AS=64.31p PD=152.2u PS=110.8u ; M device
C370c 3 0 43n                            ; C device
R370d 1 0 89k                            ; R device
R370e 2 0 50k                            ; R device
C370f 3 0 681p                           ; C device
M370g 1 2 3 0 NMOS L=0.70u W=17.7u
+ AD=17.11p AS=18.27p PD=52.1u PS=38.7u ; M device
R370h 2 0 280                            ; R device
R370i 0 1 898                            ; R device
C370j 3 1 5.8m                           ; C device
R370k 2 3 810                            ; R device
M370l 0 3 1 2 PMOS L=0.18u W=31.6u
+ AD=61.49p AS=23.93p PD=125.8u PS=121.7u ; M device
R370m 0 2 32                             ; R device
R370n 1 2 2.5M                           ; R device
R370o 0 2 21k                            ; R device
R370p 0 3 993                            ; R device
C370q 0 1 6.0m                           ; C device
M370r 0 1 2 3 NMOS L=0.10u W=21.2u       ; M device
M370s 2 1 0 3 NMOS L=0.13u W=81.9u AD=27.24p AS=27.31p PD=224.8u PS=310.4u ; M device
R370t 0 1 174                            ; R device
M370u 1 3 0 2 PMOS L=1.00u W=15.9u AD=23.10p AS=12.48p PD=45.1u PS=50.3u ; M device
C370v 2 3 3n                             ; C device
R370w 3 1 9.7M                           ; R device
M370x 1 3 2 0 NMOS L=0.25u W=12.7u       ; M device
R370y 2 1 5.4M                           ; R device
C370z 3 1 95n                            ; C device
R371a 1 2 7.4M                           ; R device
M371b 2 3 0 1 PMOS L=1.00u W=10.3u       ; M device
M371c 3 1 0 2 NMOS L=0.70u W=83.7u
+ AD=30.68p AS=123.24p PD=294.6u PS=211.8u ; M device
C371d 0 2 5.0m                           ; C device
R371e 3 2 729                            ; R device
M371f 3 0 2 1 PMOS L=0.10u W=96.8u       ; M device
M371g 0 1 2 3 PMOS L=0.35u W=13.9u       ; M device
R371h 2 1 1.7M                           ; R device
C371i 3 2 35p                            ; C device
C371j 2 1 227p                           ; C device
M371k 1 3 0 2 NMOS L=1.00u W=53.1u AD=45.84p AS=37.35p PD=129.5u PS=131.3u ; M device
M371l 0 3 2 1 NMOS L=1.00u W=85.1u       ; M device
C371m 1 3 45n                            ; C device
C371n 3 0 2.6m                           ; C device
R371o 3 1 29k                            ; R device
R371p 1 3 5.0M                           ; R device
M371q 1 2 0 3 NMOS L=0.35u W=16.8u AD=14.12p AS=31.19p PD=39.9u PS=58.5u ; M device
M371r 2 0 1 3 PMOS L=0.13u W=91.4u AD=172.09p AS=56.82p PD=249.7u PS=232.0u ; M device
M371s 0 3 1 2 NMOS L=0.10u W=21.4u
+ AD=27.55p AS=29.23p PD=82.6u PS=53.1u ; M device
R371t 1 3 5.4M                           ; R device
R371u 3 2 9.4M                           ; R device
R371v 3 0 90k                            ; R device
C371w 3 2 4.3u                           ; C device
C371x 2 0 3.4m                           ; C device
M371y 0 2 3 1 NMOS L=0.70u W=65.0u       ; M device
M371z 2 3 1 0 PMOS L=0.18u W=40.6u       ; M device
R372a 1 2 8.0M                           ; R device
R372b 0 3 2.4M                           ; R device
R372c 3 1 911                            ; R device
R372d 1 2 3.9M                           ; R device
R372e 1 3 1.2M                           ; R device
R372f 2 3 556                            ; R device
M372g 2 3 0 1 NMOS L=1.00u W=6.6u        ; M device
R372h 3 0 276                            ; R device
M372i 0 1 2 3 PMOS L=0.70u W=98.4u
+ AD=162.49p AS=67.58p PD=381.1u PS=277.8u ; M device
M372j 1 0 2 3 NMOS L=0.18u W=2.8u
+ AD=4.22p AS=1.95p PD=8.8u PS=9.6u ; M device
R372k 1 0 300                            ; R device
M372l 0 2 1 3 NMOS L=0.13u W=18.2u
+ AD=12.24p AS=5.62p PD=52.8u PS=54.7u ; M device
C372m 2 0 5.0m                           ; C device
R372n 3 0 58k                            ; R device
C372o 2 0 61p                            ; C device
C372p 3 1 5.2m                           ; C device
C372q 2 1 7.7m                           ; C device
C372r 0 3 990p                           ; C device
M372s 0 3 2 1 PMOS L=1.00u W=67.8u       ; M device
R372t 0 2 7.1M                           ; R device
C372u 2 0 863p                           ; C device
M372v 2 0 1 3 PMOS L=0.13u W=89.2u       ; M device
C372w 3 2 6.2m                           ; C device
M372x 2 0 1 3 PMOS L=0.13u W=45.3u AD=80.85p AS=33.27p PD=129.1u PS=142.7u ; M device
M372y 2 3 1 0 PMOS L=0.13u W=81.0u       ; M device
M372z 2 1 3 0 PMOS L=0.13u W=1.4u
+ AD=0.35p AS=1.01p PD=3.7u PS=4.1u ; M device
C373a 0 1 547p                           ; C device
M373b 0 2 1 3 PMOS L=0.18u W=85.2u AD=44.74p AS=152.97p PD=321.5u PS=175.5u ; M device
R373c 2 0 298                            ; R device
R373d 3 0 472                            ; R device
M373e 1 3 0 2 PMOS L=0.70u W=66.9u       ; M device
C373f 2 1 865p                           ; C device
M373g 3 2 0 1 NMOS L=1.00u W=43.2u       ; M device
M373h 1 2 0 3 NMOS L=0.50u W=71.1u       ; M device
R373i 0 2 20k                            ; R device
C373j 0 2 55n                            ; C device
R373k 1 0 87k                            ; R device
C373l 0 2 40n                            ; C device
C373m 3 2 1.8m                           ; C device
C373n 1 2 207p                           ; C device
R373o 0 2 9.3M                           ; R device
C373p 0 1 77p                            ; C device
C373q 3 2 5.8m                           ; C device
C373r 2 3 12n                            ; C device
C373s 3 1 8.8u                           ; C device
C373t 3 1 5.4m                           ; C device
C373u 2 1 954p                           ; C device
C373v 1 3 134p                           ; C device
R373w 1 0 30k                            ; R device
M373x 3 2 1 0 NMOS L=0.25u W=34.2u       ; M device
M373y 0 2 1 3 NMOS L=0.50u W=81.8u       ; M device
M373z 2 3 0 1 PMOS L=0.13u W=28.3u       ; M device
C374a 0 2 1.2m                           ; C device
C374b 3 2 6.7u                           ; C device
R374c 1 0 47                             ; R device
M374d 0 1 3 2 PMOS L=0.50u W=33.2u
+ AD=9.34p AS=14.24p PD=76.6u PS=124.4u ; M device
M374e 3 2 0 1 NMOS L=0.70u W=99.7u       ; M device
R374f 2 0 71k                            ; R device
M374g 2 1 0 3 PMOS L=0.50u W=20.1u       ; M device
M374h 1 3 0 2 NMOS L=0.25u W=18.8u       ; M device
M374i 2 0 3 1 PMOS L=0.25u W=81.3u AD=153.00p AS=124.00p PD=274.6u PS=228.7u ; M device
C374j 0 2 28n                            ; C device
M374k 3 2 1 0 PMOS L=0.18u W=22.0u
+ AD=19.92p AS=15.61p PD=83.9u PS=51.4u ; M device
R374l 2 3 4.3M                           ; R device
R374m 0 3 4.6M                           ; R device
C374n 3 1 436p                           ; C device
R374o 1 2 7.0M                           ; R device
R374p 0 3 235                            ; R device
R374q 1 0 24                             ; R device
M374r 1 0 3 2 NMOS L=0.18u W=20.3u       ; M device
R374s 2 1 529                            ; R device
R374t 0 1 3.8M                           ; R device
R374u 0 3 715                            ; R device
C374v 0 2 471p                           ; C device
C374w 3 1 3.4u                           ; C device
R374x 1 0 651                            ; R device
C374y 0 2 908p                           ; C device
C374z 3 0 3.7u                           ; C device
R375a 3 0 587                            ; R device
M375b 2 3 0 1 PMOS L=0.13u W=69.0u       ; M device
R375c 1 2 78                             ; R device
R375d 0 1 63k                            ; R device
C375e 1 2 56n                            ; C device
R375f 0 1 6.9M                           ; R device
R375g 3 2 37k                            ; R device
R375h 0 2 53                             ; R device
C375i 0 1 3.4m                           ; C device
R375j 3 0 3.6M                           ; R device
R375k 3 0 210                            ; R device
R375l 3 0 32k                            ; R device
R375m 3 0 51k                            ; R device
C375n 0 2 3.7m                           ; C device
C375o 2 0 0.2m                           ; C device
C375p 2 3 594p                           ; C device
C375q 0 2 0.7u                           ; C device
C375r 2 3 5.1m                           ; C device
R375s 3 1 59k                            ; R device
M375t 3 1 2 0 PMOS L=0.18u W=9.1u AD=11.58p AS=14.46p PD=27.0u PS=35.0u ; M device
M375u 2 3 1 0 NMOS L=0.35u W=99.6u       ; M device
R375v 1 3 85k                            ; R device
R375w 3 0 7.1M                           ; R device
M375x 2 1 0 3 PMOS L=0.35u W=51.7u AD=97.57p AS=93.22p PD=199.0u PS=135.6u ; M device
C375y 1 2 2.2m                           ; C device
R375z 1 3 262                            ; R device
M376a 0 2 1 3 PMOS L=0.13u W=45.2u
+ AD=10.36p AS=20.83p PD=154.7u PS=97.8u ; M device
M376b 2 3 0 1 NMOS L=0.10u W=15.4u AD=23.90p AS=16.97p PD=58.5u PS=50.5u ; M device
C376c 1 3 9.8u                           ; C device
R376d 2 3 59k                            ; R device
C376e 0 1 198p                           ; C device
M376f 2 0 3 1 PMOS L=0.25u W=83.6u AD=17.23p AS=34.93p PD=219.6u PS=310.2u ; M device
M376g 0 3 1 2 PMOS L=0.18u W=72.9u AD=76.12p AS=121.31p PD=212.6u PS=240.9u ; M device
M376h 0 1 2 3 PMOS L=0.35u W=36.6u AD=28.91p AS=21.57p PD=88.9u PS=111.4u ; M device
M376i 2 1 0 3 NMOS L=0.10u W=96.5u AD=128.42p AS=72.67p PD=242.3u PS=369.4u ; M device
R376j 3 1 0.1M                           ; R device
M376k 0 2 1 3 NMOS L=0.13u W=56.7u       ; M device
R376l 2 1 388                            ; R device
C376m 2 1 312p                           ; C device
M376n 0 2 3 1 PMOS L=1.00u W=7.1u
+ AD=5.02p AS=3.50p PD=19.6u PS=26.7u ; M device
R376o 0 1 17k                            ; R device
R376p 0 2 7.3M                           ; R device
R376q 3 2 258                            ; R device
M376r 2 1 0 3 PMOS L=0.25u W=67.5u       ; M device
M376s 3 1 2 0 PMOS L=0.25u W=23.5u       ; M device
R376t 0 2 73k                            ; R device
C376u 0 2 12n                            ; C device
C376v 2 3 1.9m                           ; C device
M376w 2 1 0 3 NMOS L=0.50u W=45.2u AD=11.22p AS=46.97p PD=116.4u PS=118.4u ; M device
C376x 3 0 733p                           ; C device
C376y 2 1 2.6m                           ; C device
M376z 1 0 3 2 NMOS L=0.18u W=0.6u        ; M device
R377a 2 3 2.3M                           ; R device
C377b 0 2 75n                            ; C device
R377c 3 0 504                            ; R device
C377d 1 2 8.8m                           ; C device
M377e 0 3 2 1 PMOS L=0.70u W=97.0u       ; M device
R377f 1 0 7.1M                           ; R device
M377g 1 0 3 2 NMOS L=1.00u W=18.3u AD=7.01p AS=25.21p PD=37.9u PS=39.7u ; M device
R377h 2 0 34k                            ; R device
C377i 0 2 74n                            ; C device
R377j 1 2 9.4M                           ; R device
C377k 3 0 261p                           ; C device
R377l 3 1 56k                            ; R device
R377m 0 3 0.2M                           ; R device
M377n 1 3 0 2 NMOS L=0.50u W=80.1u AD=86.85p AS=116.33p PD=237.9u PS=219.8u ; M device
R377o 0 2 510                            ; R device
C377p 1 3 2.1m                           ; C device
C377q 0 2 43n                            ; C device
C377r 0 1 71n                            ; C device
M377s 3 1 0 2 NMOS L=0.18u W=77.0u AD=149.98p AS=70.17p PD=276.2u PS=293.4u ; M device
R377t 3 0 9.0M                           ; R device
M377u 0 1 2 3 PMOS L=0.13u W=12.3u       ; M device
M377v 3 0 2 1 NMOS L=0.35u W=63.7u
+ AD=11.58p AS=49.48p PD=175.8u PS=241.1u ; M device
C377w 2 3 58n                            ; C device
C377x 1 0 23n                            ; C device
R377y 3 0 8.8M                           ; R device
M377z 3 1 0 2 NMOS L=0.25u W=59.6u       ; M device
M378a 1 3 2 0 NMOS L=0.18u W=41.1u
+ AD=73.46p AS=22.39p PD=99.5u PS=154.9u ; M device
R378b 0 1 8.0M                           ; R device
M378c 2 0 3 1 NMOS L=0.13u W=74.2u AD=136.68p AS=31.61p PD=218.2u PS=210.6u ; M device
R378d 1 2 0.7M                           ; R device
R378e 1 3 752                            ; R device
R378f 3 0 138                            ; R device
C378g 1 3 2.9u                           ; C device
M378h 2 3 0 1 NMOS L=0.25u W=55.8u AD=107.11p AS=25.39p PD=221.0u PS=195.8u ; M device
C378i 1 0 2.3m                           ; C device
R378j 2 1 4k                             ; R device
R378k 1 3 81                             ; R device
C378l 0 2 89n                            ; C device
R378m 0 2 140                            ; R device
C378n 2 3 7.3m                           ; C device
C378o 0 3 17n                            ; C device
C378p 0 3 94p                            ; C device
R378q 2 0 90k                            ; R device
M378r 2 1 3 0 PMOS L=0.18u W=2.0u        ; M device
M378s 1 0 2 3 PMOS L=1.00u W=96.9u       ; M device
M378t 1 3 2 0 PMOS L=0.10u W=39.0u
+ AD=69.96p AS=23.76p PD=127.2u PS=145.9u ; M device
R378u 1 0 27k                            ; R device
C378v 0 1 553p                           ; C device
M378w 3 2 0 1 NMOS L=0.18u W=79.4u       ; M device
M378x 1 0 2 3 PMOS L=0.50u W=75.5u       ; M device
M378y 1 2 3 0 PMOS L=1.00u W=51.9u AD=48.77p AS=46.77p PD=193.2u PS=203.9u ; M device
C378z 0 1 9.8m                           ; C device
C379a 1 2 79n                            ; C device
M379b 3 1 0 2 PMOS L=0.25u W=10.4u       ; M device
R379c 2 3 11k                            ; R device
R379d 2 3 2.8M                           ; R device
M379e 2 3 1 0 PMOS L=0.18u W=76.1u       ; M device
C379f 2 1 9.9m                           ; C device
C379g 2 1 50n                            ; C device
M379h 1 3 0 2 PMOS L=1.00u W=65.4u AD=25.77p AS=109.01p PD=160.6u PS=249.2u ; M device
M379i 3 0 1 2 PMOS L=0.50u W=68.6u
+ AD=58.57p AS=53.00p PD=210.6u PS=212.2u ; M device
R379j 0 2 6.5M                           ; R device
M379k 0 3 2 1 NMOS L=1.00u W=74.8u       ; M device
R379l 1 3 1.3M                           ; R device
M379m 0 1 3 2 PMOS L=0.13u W=49.4u       ; M device
R379n 2 0 710                            ; R device
M379o 3 2 0 1 NMOS L=1.00u W=84.2u       ; M device
M379p 1 2 0 3 NMOS L=0.13u W=62.1u
+ AD=120.82p AS=91.44p PD=237.7u PS=209.2u ; M device
M379q 1 3 2 0 PMOS L=0.25u W=40.6u
+ AD=11.44p AS=79.74p PD=125.5u PS=99.4u ; M device
M379r 0 1 2 3 PMOS L=0.13u W=35.2u AD=6.87p AS=8.76p PD=81.7u PS=73.7u ; M device
C379s 0 3 5.8u                           ; C device
C379t 2 1 9.6m                           ; C device
R379u 0 2 10k                            ; R device
M379v 3 2 0 1 PMOS L=0.25u W=76.9u       ; M device
C379w 1 2 355p                           ; C device
C379x 2 1 3.0m                           ; C device
R379y 1 2 7.4M                           ; R device
R379z 3 0 27k                            ; R device
M380a 0 2 3 1 NMOS L=0.10u W=16.1u       ; M device
M380b 1 3 0 2 PMOS L=0.13u W=88.2u AD=15.08p AS=151.31p PD=262.5u PS=229.1u ; M device
M380c 1 3 0 2 NMOS L=0.70u W=90.8u       ; M device
R380d 2 1 41k                            ; R device
R380e 3 1 57k                            ; R device
R380f 2 3 92k                            ; R device
M380g 2 1 3 0 PMOS L=0.10u W=31.3u
+ AD=57.02p AS=15.48p PD=64.5u PS=81.9u ; M device
C380h 3 0 36p                            ; C device
M380i 0 1 3 2 NMOS L=0.18u W=27.0u AD=36.68p AS=53.65p PD=106.2u PS=91.4u ; M device
R380j 3 0 40k                            ; R device
C380k 2 3 4.3m                           ; C device
M380l 1 2 0 3 PMOS L=0.35u W=43.4u
+ AD=14.99p AS=69.36p PD=169.1u PS=154.7u ; M device
C380m 0 3 23n                            ; C device
R380n 0 2 12k                            ; R device
C380o 1 2 435p                           ; C device
M380p 0 2 3 1 PMOS L=0.10u W=99.6u       ; M device
R380q 2 1 6.9M                           ; R device
R380r 1 0 8.1M                           ; R device
C380s 1 0 1.0u                           ; C device
M380t 0 1 3 2 PMOS L=0.18u W=83.4u
+ AD=165.14p AS=79.28p PD=284.4u PS=231.2u ; M device
M380u 1 3 0 2 PMOS L=0.10u W=84.5u       ; M device
C380v 0 3 8.3u                           ; C device
R380w 0 3 3.0M                           ; R device
R380x 1 2 92k                            ; R device
R380y 1 0 457                            ; R device
C380z 2 0 668p                           ; C device
C381a 3 0 7.5m                           ; C device
M381b 3 1 2 0 NMOS L=0.13u W=51.3u       ; M device
C381c 1 2 3.3m                           ; C device
M381d 3 0 2 1 PMOS L=1.00u W=88.4u
+ AD=81.73p AS=143.52p PD=229.8u PS=346.6u ; M device
C381e 2 3 6.9u                           ; C device
C381f 0 1 8.9u                           ; C device
C381g 2 1 6.5u                           ; C device
R381h 2 0 2.4M                           ; R device
M381i 3 2 0 1 NMOS L=0.10u W=15.5u       ; M device
R381j 2 0 4.6M                           ; R device
C381k 1 2 5.2m                           ; C device
R381l 2 1 245                            ; R device
R381m 2 1 22k                            ; R device
R381n 0 2 4.3M                           ; R device
R381o 0 3 65k                            ; R device
M381p 0 2 1 3 PMOS L=0.70u W=50.0u
+ AD=56.33p AS=88.50p PD=154.2u PS=119.6u ; M device
R381q 1 3 57k                            ; R device
C381r 2 3 6.1m                           ; C device
C381s 2 1 126p                           ; C device
M381t 2 1 3 0 PMOS L=0.18u W=69.8u
+ AD=95.68p AS=32.67p PD=173.6u PS=167.1u ; M device
R381u 1 0 58k                            ; R device
M381v 1 3 2 0 PMOS L=0.13u W=99.2u       ; M device
M381w 0 3 2 1 NMOS L=0.70u W=99.4u       ; M device
M381x 0 1 3 2 NMOS L=0.18u W=42.6u       ; M device
M381y 1 0 2 3 PMOS L=0.13u W=82.9u       ; M device
R381z 2 0 93k                            ; R device
C382a 3 1 41n                            ; C device
R382b 0 3 312                            ; R device
R382c 0 1 5.8M                           ; R device
C382d 0 1 6.4u                           ; C device
M382e 3 0 2 1 PMOS L=0.13u W=82.0u       ; M device
R382f 2 0 16k                            ; R device
M382g 0 1 2 3 NMOS L=0.70u W=29.3u
+ AD=38.00p AS=53.60p PD=70.4u PS=62.6u ; M device
R382h 2 0 9.7M                           ; R device
M382i 3 2 1 0 NMOS L=0.25u W=68.6u
+ AD=112.77p AS=7.18p PD=145.0u PS=199.6u ; M device
C382j 3 1 939p                           ; C device
C382k 2 1 3.3m                           ; C device
M382l 3 1 2 0 PMOS L=0.70u W=61.6u       ; M device
R382m 2 0 3.0M                           ; R device
C382n 1 3 857p                           ; C device
C382o 0 3 60n                            ; C device
C382p 1 2 846p                           ; C device
R382q 0 1 76k                            ; R device
R382r 0 2 82k                            ; R device
C382s 1 3 9.8m                           ; C device
C382t 0 1 751p                           ; C device
R382u 3 0 9.0M                           ; R device
C382v 2 0 8.6m                           ; C device
M382w 0 3 2 1 PMOS L=1.00u W=6.3u AD=1.79p AS=12.10p PD=13.9u PS=16.6u ; M device
C382x 0 3 2.6m                           ; C device
M382y 2 1 0 3 PMOS L=0.18u W=77.5u
+ AD=43.26p AS=95.20p PD=270.7u PS=256.0u ; M device
C382z 0 1 67n                            ; C device
M383a 3 2 0 1 PMOS L=0.18u W=26.2u AD=46.99p AS=10.70p PD=71.1u PS=63.5u ; M device
M383b 3 1 0 2 PMOS L=1.00u W=50.0u       ; M device
M383c 2 3 1 0 NMOS L=0.10u W=78.5u       ; M device
R383d 3 0 353                            ; R device
C383e 0 1 33n                            ; C device
C383f 0 2 375p                           ; C device
R383g 3 2 51k                            ; R device
C383h 1 3 2.7u                           ; C device
M383i 3 1 2 0 NMOS L=0.13u W=70.7u AD=120.99p AS=15.92p PD=257.7u PS=265.3u ; M device
C383j 0 1 52n                            ; C device
R383k 2 3 27                             ; R device
M383l 1 3 0 2 NMOS L=0.35u W=23.2u       ; M device
M383m 3 0 1 2 PMOS L=0.25u W=42.2u
+ AD=31.39p AS=42.38p PD=133.4u PS=114.5u ; M device
R383n 2 3 72k                            ; R device
C383o 2 0 37n                            ; C device
M383p 0 2 3 1 PMOS L=1.00u W=8.7u AD=13.89p AS=2.84p PD=30.5u PS=32.3u ; M device
R383q 2 1 58k                            ; R device
M383r 0 1 2 3 NMOS L=0.13u W=16.7u       ; M device
R383s 0 1 4.1M                           ; R device
C383t 2 1 90n                            ; C device
C383u 2 1 639p                           ; C device
C383v 2 3 0.6u                           ; C device
M383w 1 0 2 3 NMOS L=0.35u W=37.5u
+ AD=39.43p AS=17.27p PD=106.3u PS=103.3u ; M device
C383x 0 1 68n                            ; C device
R383y 1 2 22k                            ; R device
R383z 1 0 6.2M                           ; R device
R384a 2 0 2.7M                           ; R device
M384b 1 0 3 2 PMOS L=1.00u W=73.3u
+ AD=36.01p AS=103.57p PD=291.7u PS=215.3u ; M device
C384c 1 2 4.9m                           ; C device
C384d 2 3 10n                            ; C device
C384e 0 2 25n                            ; C device
C384f 0 2 503p                           ; C device
M384g 3 1 2 0 NMOS L=0.70u W=35.0u
+ AD=12.13p AS=10.49p PD=103.1u PS=103.7u ; M device
R384h 2 0 88k                            ; R device
R384i 1 0 1.4M                           ; R device
M384j 2 0 3 1 NMOS L=0.70u W=44.5u AD=9.84p AS=30.62p PD=158.2u PS=136.0u ; M device
C384k 2 0 8.5u                           ; C device
M384l 2 1 0 3 NMOS L=0.70u W=93.8u
+ AD=41.28p AS=78.30p PD=261.5u PS=265.9u ; M device
M384m 3 2 0 1 NMOS L=0.35u W=53.6u AD=36.60p AS=99.04p PD=172.3u PS=158.9u ; M device
R384n 1 2 3.5M                           ; R device
M384o 2 3 1 0 PMOS L=0.13u W=23.9u
+ AD=26.32p AS=9.34p PD=54.9u PS=67.9u ; M device
R384p 3 1 61k                            ; R device
R384q 0 3 3.2M                           ; R device
M384r 3 2 1 0 PMOS L=0.25u W=21.1u
+ AD=6.62p AS=7.70p PD=53.8u PS=45.7u ; M device
R384s 2 0 6.0M                           ; R device
C384t 1 2 1.7m                           ; C device
M384u 0 3 2 1 NMOS L=0.13u W=5.3u        ; M device
C384v 1 2 14n                            ; C device
M384w 1 3 0 2 PMOS L=0.25u W=55.7u       ; M device
R384x 1 0 38k                            ; R device
C384y 1 0 40n                            ; C device
C384z 0 1 1.2m                           ; C device
C385a 2 3 85n                            ; C device
M385b 2 0 1 3 PMOS L=1.00u W=79.7u
+ AD=70.76p AS=84.92p PD=298.7u PS=243.3u ; M device
M385c 0 2 1 3 PMOS L=0.13u W=57.6u AD=23.53p AS=68.38p PD=141.1u PS=223.8u ; M device
M385d 2 0 1 3 PMOS L=0.10u W=21.0u AD=24.31p AS=10.91p PD=69.5u PS=67.9u ; M device
C385e 1 2 619p                           ; C device
R385f 1 2 5.1M                           ; R device
M385g 0 3 2 1 PMOS L=0.25u W=36.0u AD=48.58p AS=59.17p PD=75.3u PS=92.0u ; M device
C385h 3 2 40n                            ; C device
C385i 1 3 0.7m                           ; C device
C385j 3 1 6.4u                           ; C device
C385k 2 1 52n                            ; C device
R385l 3 0 6.4M                           ; R device
M385m 0 1 3 2 PMOS L=0.35u W=55.1u       ; M device
M385n 1 2 3 0 PMOS L=0.18u W=73.7u AD=104.04p AS=85.83p PD=275.0u PS=207.3u ; M device
C385o 1 3 755p                           ; C device
R385p 1 0 398                            ; R device
* SPICE Model Definitions
.MODEL NMOS NMOS (LEVEL=1 VTO=0.7 KP=110E-6 LAMBDA=0.04
+            TOX=9E-9 NSUB=1E17 GAMMA=0.4 PHI=0.7)
.MODEL PMOS PMOS (LEVEL=1 VTO=-0.7 KP=50E-6 LAMBDA=0.05
+            TOX=9E-9 NSUB=1E17 GAMMA=0.5 PHI=0.8)
.OP
.END
