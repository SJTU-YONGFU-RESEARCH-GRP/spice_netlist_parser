* Random SPICE Netlist
V1a 0 1 SIN(0
+ 7.4 7605)
C1b 0 1 40n
R1c 0 1 63k
R1d 0 1 48k
C1e 0 1 4.9u
R1f 0 1 71k
R1g 1 0 79k
R1h 1 0 68k
C1i 0 1 2.4u
R1j 0 1 463
R1k 0 1 394
M1l 0 2 3 1 NMOS L=0.25u W=50.8u
C1m 1 2 9.1u
R1n 2 0 97k
R1o 0 1 9k
M1p 3 1 2 0 PMOS L=0.70u W=24.1u AD=29.98p AS=10.82p PD=49.0u PS=66.3u
C1q 3 0 79n
C1r 0 3 72n
C1s 1 2 624p
M1t 0 1 2 3 NMOS L=0.50u W=69.1u
R1u 1 3 56
M1v 0 2 1 3 NMOS L=0.25u W=37.3u
+ AD=35.02p AS=50.44p PD=129.5u PS=78.7u
M1w 3 0 2 1 PMOS L=0.10u W=27.5u
+ AD=22.19p AS=42.92p PD=60.3u PS=91.6u
C1x 1 0 6.5m
M1y 2 0 3 1 NMOS L=0.13u W=84.6u
R1z 3 1 889
M2a 1 2 3 0 PMOS L=0.70u W=8.7u
C2b 3 2 1.8m
R2c 2 0 7k
C2d 1 3 836p
C2e 2 1 4.0m
R2f 2 3 3.4M
C2g 3 2 707p
C2h 2 0 3.1u
M2i 1 3 0 2 PMOS L=0.50u W=65.3u AD=58.52p AS=89.01p PD=244.5u PS=178.7u
R2j 2 0 843
R2k 0 2 5k
C2l 0 3 2.9u
C2m 0 1 6.6u
R2n 0 1 87k
M2o 1 0 3 2 PMOS L=0.13u W=90.9u AD=95.60p AS=95.23p PD=218.2u PS=183.7u
M2p 2 1 0 3 NMOS L=0.10u W=71.1u
+ AD=16.08p AS=85.68p PD=279.4u PS=282.2u
M2q 0 3 2 1 NMOS L=0.50u W=98.6u AD=101.47p AS=76.63p PD=297.8u PS=239.5u
M2r 2 0 3 1 NMOS L=0.70u W=81.2u
+ AD=118.39p AS=104.31p PD=323.7u PS=258.6u
M2s 2 1 0 3 PMOS L=0.13u W=81.6u AD=38.45p AS=139.43p PD=185.2u PS=248.7u
M2t 0 1 3 2 PMOS L=0.10u W=79.4u
+ AD=60.54p AS=137.18p PD=175.6u PS=238.3u
C2u 2 1 0.9u
M2v 0 2 3 1 NMOS L=0.25u W=42.5u
+ AD=18.91p AS=79.20p PD=147.3u PS=120.0u
M2w 0 3 2 1 NMOS L=0.18u W=9.9u
M2x 0 1 3 2 PMOS L=0.50u W=2.6u AD=1.93p AS=4.14p PD=8.0u PS=7.8u
C2y 1 3 6.6m
C2z 1 0 9.2m
C3a 2 0 2.1u
M3b 1 2 3 0 NMOS L=1.00u W=89.0u AD=130.89p AS=162.09p PD=243.7u PS=255.2u
C3c 2 1 6.7u
M3d 0 3 2 1 PMOS L=0.70u W=51.4u
R3e 0 1 73k
C3f 3 0 9.2m
C3g 1 3 63n
M3h 3 1 0 2 PMOS L=1.00u W=88.7u
R3i 1 3 95k
R3j 2 0 406
M3k 0 2 1 3 PMOS L=0.70u W=82.6u
+ AD=14.51p AS=151.30p PD=232.4u PS=241.6u
M3l 2 1 0 3 NMOS L=0.70u W=29.1u
C3m 2 0 94n
M3n 1 0 2 3 NMOS L=0.18u W=90.6u
C3o 0 1 9.0u
C3p 3 1 2.4m
C3q 3 2 658p
R3r 2 0 1.1M
C3s 2 1 7.4u
C3t 2 1 1.3u
R3u 2 3 25k
R3v 3 2 730
C3w 0 1 478p
C3x 0 3 85p
C3y 0 1 8.9m
R3z 3 1 150
C4a 0 2 173p
R4b 2 3 7.3M
C4c 3 0 67n
R4d 0 1 31k
M4e 2 1 3 0 NMOS L=0.70u W=84.1u
M4f 3 2 1 0 PMOS L=1.00u W=16.1u
M4g 2 3 1 0 PMOS L=0.25u W=80.7u
R4h 3 1 1.4M
M4i 2 3 0 1 PMOS L=0.50u W=89.9u
M4j 3 2 0 1 PMOS L=0.10u W=42.8u AD=49.28p AS=48.77p PD=104.6u PS=93.1u
M4k 3 0 2 1 PMOS L=1.00u W=47.4u AD=88.30p AS=17.05p PD=103.6u PS=117.7u
R4l 3 2 9.0M
R4m 3 1 895
M4n 1 0 3 2 PMOS L=0.70u W=92.0u
M4o 1 3 2 0 PMOS L=0.35u W=66.2u AD=62.37p AS=114.60p PD=189.4u PS=152.8u
R4p 2 1 0.8M
M4q 2 3 1 0 NMOS L=0.18u W=5.9u
+ AD=8.04p AS=8.01p PD=19.9u PS=16.5u
R4r 0 2 328
M4s 2 1 0 3 PMOS L=0.25u W=98.5u AD=133.15p AS=31.63p PD=335.3u PS=375.9u
M4t 3 0 2 1 NMOS L=0.10u W=71.1u AD=135.07p AS=118.36p PD=211.0u PS=283.7u
C4u 0 1 6.1u
R4v 3 0 4.6M
* SPICE Model Definitions
.MODEL NMOS NMOS (LEVEL=1 VTO=0.7 KP=110E-6 LAMBDA=0.04
+            TOX=9E-9 NSUB=1E17 GAMMA=0.4 PHI=0.7)
.MODEL PMOS PMOS (LEVEL=1 VTO=-0.7 KP=50E-6 LAMBDA=0.05
+            TOX=9E-9 NSUB=1E17 GAMMA=0.5 PHI=0.8)
.OP
.END
