* Random SPICE Netlist
V1a 0 1 SIN(0 8.6 8793)
R1b 0 1 25k
M1c 3 2 0 1 NMOS L=0.18u W=82.8u
+ AD=37.32p AS=32.03p PD=289.9u PS=198.4u
M1d 3 2 1 0 PMOS L=0.10u W=38.8u
+ AD=19.84p AS=7.58p PD=79.2u PS=95.9u
M1e 2 1 3 0 NMOS L=0.25u W=72.5u
M1f 3 0 2 1 NMOS L=0.35u W=1.2u
M1g 3 1 0 2 PMOS L=0.35u W=55.3u
C1h 3 2 5.0u
R1i 0 3 72k
C1j 1 2 4.8u
M1k 0 3 2 1 PMOS L=0.10u W=48.6u AD=13.00p AS=82.38p PD=157.5u PS=139.2u
M1l 1 0 2 3 PMOS L=0.10u W=76.1u AD=49.80p AS=26.69p PD=276.7u PS=157.1u
M1m 0 2 3 1 NMOS L=0.35u W=82.4u
+ AD=154.11p AS=117.26p PD=227.2u PS=211.8u
M1n 0 1 3 2 PMOS L=0.25u W=29.8u
C1o 0 1 7.1m
R1p 0 3 423
R1q 0 3 8.2M
C1r 3 2 6.7m
M1s 0 3 2 1 NMOS L=0.10u W=24.5u
M1t 2 0 3 1 PMOS L=0.10u W=4.2u
+ AD=6.43p AS=6.04p PD=13.7u PS=12.3u
M1u 2 3 0 1 NMOS L=0.18u W=57.6u
M1v 1 0 3 2 PMOS L=0.13u W=62.1u AD=49.93p AS=20.30p PD=187.8u PS=184.0u
R1w 3 1 87k
M1x 3 0 1 2 PMOS L=0.10u W=74.3u AD=50.97p AS=87.73p PD=153.8u PS=177.9u
M1y 1 0 3 2 NMOS L=0.50u W=1.6u
M1z 2 1 3 0 NMOS L=0.10u W=17.3u AD=13.52p AS=5.05p PD=43.8u PS=38.8u
C2a 1 2 6.9u
C2b 0 3 55p
C2c 3 2 2.7u
C2d 1 3 7.9u
R2e 3 1 749
C2f 3 1 2n
R2g 0 1 669
R2h 3 2 82k
M2i 2 3 0 1 NMOS L=1.00u W=14.4u
+ AD=2.50p AS=8.95p PD=53.0u PS=51.5u
M2j 2 0 3 1 PMOS L=0.35u W=29.0u
+ AD=39.61p AS=51.65p PD=65.6u PS=100.7u
C2k 1 0 0.4m
C2l 2 1 14n
C2m 1 0 3.8m
M2n 0 1 2 3 PMOS L=0.35u W=41.0u
M2o 3 0 1 2 NMOS L=0.50u W=96.8u
+ AD=125.54p AS=14.80p PD=238.9u PS=353.6u
R2p 0 3 2.0M
M2q 0 1 2 3 PMOS L=0.25u W=0.6u
R2r 0 3 2.9M
C2s 2 3 1.9m
C2t 3 2 70p
M2u 2 3 0 1 NMOS L=0.50u W=38.0u
R2v 2 3 7.1M
C2w 1 3 92n
M2x 0 2 1 3 NMOS L=0.10u W=3.0u AD=5.70p AS=3.04p PD=10.5u PS=11.0u
M2y 0 2 1 3 NMOS L=0.10u W=42.0u
+ AD=50.01p AS=30.75p PD=163.6u PS=141.4u
M2z 3 2 0 1 NMOS L=0.10u W=30.3u AD=43.67p AS=52.34p PD=98.4u PS=68.0u
M3a 1 0 3 2 PMOS L=0.35u W=41.7u AD=13.35p AS=23.27p PD=129.5u PS=134.9u
R3b 2 0 3.4M
C3c 2 1 6.9u
R3d 2 1 103
M3e 0 1 3 2 PMOS L=0.13u W=62.7u
C3f 1 2 6.0u
M3g 2 3 1 0 PMOS L=0.70u W=93.2u AD=182.70p AS=124.57p PD=203.6u PS=305.8u
R3h 1 2 1.8M
R3i 0 3 343
R3j 0 1 375
M3k 3 0 2 1 NMOS L=0.25u W=68.1u AD=23.52p AS=36.27p PD=261.6u PS=188.0u
M3l 2 1 0 3 NMOS L=0.10u W=33.4u
M3m 2 3 0 1 PMOS L=0.10u W=3.7u AD=2.44p AS=4.27p PD=11.1u PS=8.3u
R3n 2 1 24
C3o 3 0 43n
C3p 3 1 9.6m
M3q 1 3 2 0 PMOS L=0.13u W=10.7u
+ AD=3.51p AS=5.49p PD=33.9u PS=37.4u
R3r 3 2 58k
C3s 1 0 7.2u
R3t 0 1 384
R3u 3 2 7.3M
C3v 1 3 5.8u
R3w 3 2 304
M3x 2 3 0 1 PMOS L=0.18u W=44.4u
M3y 3 0 1 2 PMOS L=0.35u W=88.2u
+ AD=88.88p AS=55.50p PD=307.0u PS=223.9u
M3z 2 1 3 0 NMOS L=0.35u W=9.7u
M4a 3 1 0 2 NMOS L=0.70u W=84.7u
R4b 2 0 8.6M
C4c 1 0 28p
C4d 2 0 83n
C4e 2 1 41n
M4f 1 3 2 0 NMOS L=0.25u W=4.3u
M4g 2 3 0 1 NMOS L=0.70u W=18.0u
M4h 3 2 0 1 PMOS L=0.50u W=19.2u
M4i 3 2 0 1 NMOS L=0.50u W=32.6u AD=11.31p AS=11.66p PD=117.8u PS=71.7u
R4j 0 3 14k
C4k 1 0 1.4u
R4l 2 0 339
R4m 3 1 76
M4n 1 2 0 3 NMOS L=0.13u W=17.3u
M4o 3 2 1 0 NMOS L=1.00u W=94.4u
+ AD=70.96p AS=68.62p PD=284.8u PS=365.2u
C4p 1 0 2.0m
M4q 1 2 3 0 PMOS L=0.10u W=62.3u
C4r 0 2 8n
R4s 2 1 394
M4t 0 3 2 1 PMOS L=0.70u W=83.1u
M4u 3 0 1 2 NMOS L=0.35u W=71.5u AD=63.34p AS=91.40p PD=249.4u PS=282.0u
M4v 2 1 0 3 PMOS L=0.10u W=79.4u
R4w 0 2 2.1M
C4x 3 2 776p
C4y 3 0 372p
C4z 2 3 5.2m
M5a 2 0 1 3 NMOS L=0.50u W=62.4u
M5b 2 1 0 3 NMOS L=0.18u W=44.5u
C5c 2 0 3.3m
R5d 3 2 3.3M
R5e 2 0 976
R5f 2 1 86
C5g 3 2 980p
R5h 3 1 81k
R5i 2 0 9k
C5j 2 1 9.7m
M5k 1 2 3 0 PMOS L=0.25u W=2.9u AD=3.91p AS=3.09p PD=11.3u PS=11.1u
C5l 2 0 1.2u
R5m 3 1 1.3M
M5n 1 3 2 0 PMOS L=0.18u W=46.7u
C5o 2 0 88n
M5p 1 0 3 2 PMOS L=0.35u W=48.2u
+ AD=26.85p AS=44.82p PD=107.0u PS=131.9u
R5q 0 3 150
R5r 2 1 157
R5s 3 1 627
R5t 0 1 966
R5u 1 0 449
C5v 1 0 8.3m
M5w 2 1 0 3 PMOS L=0.18u W=23.9u
C5x 1 3 1.9m
M5y 0 1 2 3 PMOS L=0.18u W=19.3u
C5z 3 2 1.7m
M6a 0 2 1 3 NMOS L=0.18u W=21.9u
C6b 0 1 8.8m
R6c 0 2 69k
R6d 1 3 841
M6e 0 1 3 2 PMOS L=1.00u W=24.1u
M6f 2 3 0 1 NMOS L=0.18u W=49.9u AD=77.99p AS=43.46p PD=109.2u PS=147.5u
C6g 0 1 436p
R6h 2 0 0.2M
M6i 1 2 0 3 NMOS L=0.13u W=91.6u AD=15.45p AS=125.94p PD=258.1u PS=294.8u
R6j 3 1 8.8M
R6k 3 1 880
R6l 2 3 7.6M
C6m 2 3 3.1m
R6n 2 1 41k
C6o 3 1 52p
R6p 0 3 73k
M6q 2 0 1 3 PMOS L=1.00u W=15.2u
M6r 3 2 0 1 PMOS L=0.10u W=31.1u AD=22.36p AS=43.73p PD=64.3u PS=85.4u
R6s 2 0 3.7M
R6t 2 1 4.1M
C6u 1 3 3.3u
M6v 2 0 1 3 PMOS L=0.50u W=64.9u
C6w 3 1 6.2u
M6x 0 3 2 1 PMOS L=0.13u W=54.9u
+ AD=70.79p AS=23.99p PD=114.0u PS=155.1u
C6y 0 3 300p
M6z 2 3 0 1 PMOS L=0.13u W=33.5u
+ AD=14.69p AS=18.25p PD=111.1u PS=108.9u
R7a 0 1 790
R7b 0 3 5.1M
M7c 0 1 2 3 PMOS L=0.35u W=66.4u
C7d 1 2 859p
R7e 0 3 77k
R7f 1 0 141
M7g 1 0 2 3 PMOS L=0.18u W=80.1u
C7h 1 0 645p
C7i 3 1 4n
M7j 0 1 2 3 NMOS L=0.18u W=12.3u
+ AD=13.03p AS=14.31p PD=29.5u PS=39.2u
R7k 2 0 737
C7l 2 1 73p
M7m 2 1 0 3 PMOS L=0.13u W=48.8u
R7n 3 0 25k
M7o 0 2 3 1 PMOS L=0.70u W=20.0u
M7p 1 0 2 3 NMOS L=0.13u W=14.4u AD=23.59p AS=26.49p PD=40.8u PS=32.6u
R7q 2 1 7.0M
C7r 1 2 16p
C7s 3 1 6.8u
M7t 2 1 3 0 NMOS L=0.18u W=68.7u
C7u 2 1 79n
C7v 1 0 153p
C7w 0 2 699p
C7x 2 1 943p
R7y 1 3 719
C7z 0 1 4.6u
R8a 1 2 4.6M
C8b 1 2 5.7m
C8c 1 2 3.6m
R8d 2 3 738
M8e 0 2 1 3 PMOS L=0.35u W=85.6u
R8f 1 0 11
C8g 3 2 6.7u
C8h 1 0 74n
C8i 1 2 1.6u
R8j 3 2 545
C8k 0 3 6.4m
M8l 1 3 0 2 PMOS L=0.13u W=12.9u
R8m 0 3 10k
C8n 2 3 703p
M8o 3 2 1 0 PMOS L=0.10u W=94.2u
M8p 1 3 0 2 PMOS L=0.13u W=11.7u
C8q 0 1 81n
R8r 1 0 829
R8s 0 2 950
R8t 2 0 75k
R8u 1 0 6.5M
C8v 2 1 307p
C8w 3 2 191p
M8x 3 0 2 1 PMOS L=0.35u W=83.6u AD=29.27p AS=42.89p PD=187.2u PS=236.4u
C8y 2 3 3.3u
R8z 3 0 95k
C9a 3 1 31p
C9b 1 2 7.5m
M9c 1 3 2 0 NMOS L=1.00u W=37.3u
C9d 0 2 9.4u
M9e 0 3 1 2 PMOS L=0.50u W=76.0u
R9f 2 1 1.1M
R9g 1 2 4.9M
R9h 0 3 5.8M
C9i 3 2 509p
M9j 0 3 1 2 NMOS L=0.10u W=86.8u
R9k 1 3 55k
M9l 0 1 3 2 NMOS L=0.25u W=24.9u
C9m 2 3 416p
M9n 0 2 3 1 NMOS L=0.50u W=11.0u
+ AD=2.75p AS=18.93p PD=28.4u PS=40.3u
M9o 0 3 1 2 PMOS L=0.10u W=28.3u
R9p 0 3 8.6M
R9q 1 3 40k
R9r 0 3 11k
M9s 2 0 1 3 PMOS L=0.70u W=20.8u
M9t 0 1 3 2 NMOS L=0.70u W=96.4u
M9u 1 2 3 0 NMOS L=0.35u W=69.8u AD=30.53p AS=111.82p PD=164.1u PS=276.6u
C9v 1 2 252p
R9w 2 1 4k
C9x 1 0 5.2u
R9y 1 0 910
C9z 2 1 79n
R10a 3 1 434
C10b 2 1 6.4u
R10c 3 1 74k
R10d 1 0 919
R10e 2 3 36k
C10f 0 1 374p
C10g 1 0 5.7u
C10h 3 2 1.6u
R10i 0 2 29k
C10j 1 3 17n
M10k 1 2 0 3 NMOS L=0.13u W=69.4u
+ AD=30.34p AS=20.38p PD=175.4u PS=206.1u
C10l 3 1 8.5m
C10m 1 2 4.1m
R10n 3 0 25
R10o 3 2 65k
C10p 3 0 209p
R10q 2 1 59k
M10r 1 0 2 3 PMOS L=1.00u W=29.6u
M10s 3 2 0 1 NMOS L=0.10u W=91.9u AD=47.59p AS=34.48p PD=311.2u PS=264.7u
C10t 2 3 689p
R10u 2 3 0.4M
M10v 0 3 1 2 NMOS L=0.50u W=59.8u AD=81.34p AS=79.37p PD=232.9u PS=219.2u
M10w 1 0 3 2 NMOS L=0.25u W=2.4u
+ AD=0.84p AS=0.73p PD=5.6u PS=6.1u
M10x 1 0 2 3 PMOS L=0.25u W=77.2u AD=84.33p AS=148.90p PD=187.0u PS=160.4u
R10y 3 2 526
C10z 1 3 1.8m
M11a 2 0 3 1 PMOS L=0.50u W=99.9u AD=178.44p AS=49.15p PD=324.1u PS=284.3u
M11b 2 0 3 1 NMOS L=1.00u W=78.5u
C11c 3 1 3.7u
C11d 0 3 5.3u
C11e 0 1 7.6u
C11f 1 3 7.4m
C11g 1 0 7.4m
M11h 3 0 1 2 PMOS L=0.10u W=90.4u
R11i 1 2 36k
M11j 3 2 0 1 NMOS L=0.10u W=76.6u
C11k 2 3 187p
M11l 1 0 3 2 NMOS L=0.18u W=77.6u
+ AD=37.06p AS=123.18p PD=227.7u PS=183.8u
M11m 0 2 3 1 PMOS L=0.25u W=15.8u
R11n 0 2 194
M11o 2 1 3 0 PMOS L=0.25u W=28.4u
C11p 2 0 7.6m
R11q 3 1 396
C11r 0 2 0.5m
M11s 1 2 3 0 NMOS L=0.10u W=74.7u AD=23.00p AS=57.01p PD=207.6u PS=293.1u
R11t 3 0 6.2M
C11u 0 1 658p
R11v 2 1 26k
C11w 1 3 2.7m
M11x 0 1 3 2 NMOS L=0.18u W=3.1u
+ AD=3.15p AS=0.70p PD=6.5u PS=8.1u
M11y 2 3 0 1 PMOS L=0.50u W=73.7u
M11z 2 3 0 1 NMOS L=0.70u W=30.4u AD=41.67p AS=6.15p PD=83.4u PS=63.6u
C12a 2 1 447p
R12b 2 0 10.0M
R12c 2 1 166
M12d 3 0 2 1 NMOS L=0.10u W=12.5u
C12e 1 3 106p
R12f 3 2 108
C12g 3 1 28n
R12h 0 3 6.5M
C12i 0 3 875p
R12j 2 3 67k
C12k 3 2 695p
M12l 0 3 1 2 PMOS L=0.25u W=54.5u
R12m 2 0 599
M12n 1 3 2 0 NMOS L=0.70u W=9.4u
C12o 2 1 28n
M12p 3 0 2 1 PMOS L=0.25u W=81.3u
M12q 0 3 1 2 PMOS L=1.00u W=79.2u
M12r 2 1 3 0 NMOS L=0.70u W=6.9u
M12s 2 0 3 1 PMOS L=0.35u W=96.3u AD=174.81p AS=26.32p PD=330.9u PS=237.5u
R12t 2 1 911
R12u 2 0 525
M12v 0 1 3 2 PMOS L=0.10u W=91.6u
C12w 0 1 745p
R12x 1 0 10.0M
M12y 2 3 0 1 PMOS L=0.10u W=66.9u
R12z 1 2 917
M13a 1 2 0 3 NMOS L=1.00u W=12.3u
+ AD=7.98p AS=11.32p PD=44.2u PS=24.6u
M13b 0 3 1 2 NMOS L=0.13u W=15.5u AD=20.48p AS=17.01p PD=41.9u PS=55.7u
M13c 3 0 2 1 PMOS L=0.10u W=8.9u
M13d 1 2 0 3 NMOS L=0.50u W=86.2u
M13e 1 3 2 0 NMOS L=0.18u W=72.8u
+ AD=118.46p AS=88.37p PD=179.4u PS=271.9u
R13f 2 0 33
M13g 1 3 0 2 NMOS L=0.70u W=17.2u AD=32.54p AS=6.76p PD=56.8u PS=59.5u
M13h 3 1 2 0 PMOS L=1.00u W=15.1u
+ AD=3.43p AS=1.64p PD=41.7u PS=54.5u
C13i 0 1 2.6m
M13j 2 0 1 3 PMOS L=0.35u W=83.4u AD=65.85p AS=121.08p PD=305.4u PS=259.9u
M13k 3 2 0 1 NMOS L=0.70u W=86.2u AD=66.28p AS=164.16p PD=237.7u PS=229.2u
C13l 3 0 2.8m
C13m 3 1 123p
M13n 0 1 3 2 PMOS L=1.00u W=79.2u
+ AD=88.82p AS=24.77p PD=192.5u PS=210.3u
R13o 2 3 85k
M13p 0 3 1 2 PMOS L=0.25u W=1.2u
+ AD=0.66p AS=1.98p PD=2.5u PS=4.6u
R13q 3 0 99k
M13r 3 0 1 2 NMOS L=0.10u W=8.0u AD=2.18p AS=13.94p PD=27.2u PS=25.3u
R13s 3 2 6.8M
M13t 3 0 1 2 NMOS L=0.10u W=52.5u AD=29.40p AS=30.74p PD=194.1u PS=139.7u
C13u 3 1 9.7u
M13v 1 3 2 0 NMOS L=0.35u W=91.3u
M13w 3 1 2 0 NMOS L=0.10u W=91.3u
R13x 2 1 885
M13y 0 1 3 2 NMOS L=0.50u W=75.0u
M13z 2 3 0 1 NMOS L=1.00u W=22.3u AD=34.26p AS=2.66p PD=73.4u PS=84.9u
C14a 0 2 0.3u
R14b 0 1 9.5M
M14c 2 3 1 0 PMOS L=0.35u W=92.4u
+ AD=107.24p AS=181.12p PD=238.2u PS=307.5u
C14d 0 3 79n
M14e 0 3 2 1 PMOS L=1.00u W=68.5u
+ AD=128.34p AS=132.72p PD=218.4u PS=225.7u
R14f 1 0 4.0M
R14g 0 1 396
R14h 3 2 441
R14i 1 0 4.4M
C14j 3 1 2.1u
C14k 2 1 20n
M14l 2 0 1 3 NMOS L=1.00u W=38.1u
M14m 3 0 2 1 NMOS L=1.00u W=50.1u
+ AD=17.84p AS=66.95p PD=142.9u PS=198.5u
M14n 2 0 3 1 NMOS L=0.25u W=42.7u
+ AD=80.65p AS=79.24p PD=128.6u PS=168.6u
M14o 0 2 3 1 NMOS L=0.18u W=66.5u
M14p 1 2 3 0 NMOS L=0.18u W=76.4u AD=64.18p AS=14.22p PD=181.0u PS=266.2u
R14q 2 3 240
M14r 1 0 2 3 NMOS L=0.25u W=96.0u
C14s 0 1 331p
M14t 1 3 2 0 PMOS L=0.25u W=38.0u AD=17.11p AS=16.36p PD=146.2u PS=95.8u
C14u 3 1 140p
M14v 2 0 3 1 NMOS L=0.50u W=32.0u
C14w 2 1 8.1m
M14x 0 2 3 1 PMOS L=0.70u W=24.6u
M14y 0 3 2 1 NMOS L=0.10u W=20.6u
R14z 1 2 775
M15a 1 3 2 0 NMOS L=0.18u W=44.6u
C15b 3 2 75n
C15c 1 2 57n
C15d 1 0 3.4u
R15e 1 2 125
M15f 0 1 2 3 PMOS L=0.50u W=87.9u AD=114.86p AS=122.62p PD=248.7u PS=246.6u
M15g 0 1 3 2 NMOS L=0.18u W=43.0u
M15h 2 1 3 0 NMOS L=0.13u W=18.9u
R15i 2 1 731
R15j 0 2 8.6M
C15k 1 3 942p
C15l 3 1 6.0m
R15m 0 2 58k
R15n 1 3 4k
M15o 2 1 0 3 NMOS L=0.18u W=3.7u
+ AD=3.88p AS=3.82p PD=12.2u PS=11.4u
R15p 2 0 4.5M
C15q 2 3 65n
C15r 1 2 5.9m
C15s 3 0 4.6m
M15t 0 1 2 3 PMOS L=0.35u W=4.4u
R15u 1 0 846
R15v 1 0 9.0M
R15w 1 3 105
R15x 3 2 725
C15y 0 2 8.9m
R15z 3 2 15k
M16a 2 3 0 1 PMOS L=0.50u W=13.0u AD=4.50p AS=19.59p PD=42.2u PS=31.9u
C16b 1 2 7.7u
R16c 2 1 550
C16d 3 1 352p
R16e 1 2 772
C16f 0 3 693p
M16g 2 0 1 3 PMOS L=0.10u W=45.0u
M16h 0 1 2 3 PMOS L=0.70u W=97.8u AD=34.69p AS=111.08p PD=332.6u PS=266.4u
M16i 1 3 0 2 NMOS L=0.70u W=44.5u
R16j 1 2 2.3M
C16k 3 1 74n
M16l 0 2 3 1 PMOS L=0.18u W=54.9u AD=101.70p AS=23.61p PD=123.9u PS=123.4u
R16m 3 1 316
M16n 0 1 3 2 PMOS L=0.10u W=92.0u
M16o 3 1 2 0 NMOS L=0.25u W=20.9u AD=35.17p AS=21.53p PD=72.7u PS=79.0u
R16p 3 1 859
R16q 1 2 56k
R16r 0 2 41k
C16s 3 0 63n
M16t 1 0 2 3 NMOS L=1.00u W=35.9u AD=18.61p AS=14.68p PD=94.5u PS=134.0u
R16u 1 3 9.7M
R16v 0 2 7.4M
R16w 3 0 334
R16x 1 0 74k
C16y 3 2 6.2m
M16z 2 3 0 1 NMOS L=0.10u W=19.8u AD=15.56p AS=31.00p PD=70.6u PS=44.1u
R17a 2 1 476
C17b 0 2 3.1m
C17c 2 1 68n
M17d 2 1 0 3 NMOS L=0.10u W=57.1u
C17e 1 2 8.6u
M17f 2 0 3 1 NMOS L=0.25u W=48.3u
M17g 3 0 1 2 PMOS L=0.18u W=52.1u
R17h 2 3 57k
M17i 1 0 2 3 NMOS L=0.70u W=15.4u
M17j 0 1 3 2 NMOS L=0.13u W=72.3u
R17k 1 2 66k
M17l 1 2 3 0 PMOS L=0.35u W=90.5u
R17m 2 0 3.5M
C17n 0 1 71n
M17o 1 0 2 3 NMOS L=1.00u W=36.3u
C17p 2 1 368p
R17q 3 0 6.6M
C17r 3 2 8n
M17s 2 3 0 1 PMOS L=0.25u W=14.6u AD=10.21p AS=18.33p PD=31.2u PS=35.0u
C17t 1 2 907p
M17u 3 2 0 1 NMOS L=1.00u W=12.7u AD=15.72p AS=24.65p PD=38.5u PS=42.4u
M17v 1 2 0 3 NMOS L=0.70u W=22.2u
M17w 3 2 0 1 PMOS L=0.13u W=54.3u
M17x 3 2 0 1 PMOS L=0.50u W=13.2u
C17y 1 0 862p
C17z 3 1 6.4m
M18a 1 0 2 3 NMOS L=0.50u W=45.7u
C18b 3 1 5.3m
C18c 3 2 60n
M18d 3 2 0 1 PMOS L=0.25u W=67.2u
C18e 3 1 914p
C18f 2 3 2.3u
R18g 3 0 5.1M
C18h 0 2 8.3u
R18i 3 0 31k
C18j 1 2 911p
C18k 0 2 798p
C18l 3 1 940p
M18m 1 0 3 2 NMOS L=0.10u W=78.9u
M18n 1 0 3 2 NMOS L=0.18u W=47.2u
C18o 3 1 475p
C18p 0 3 7.2u
C18q 1 0 9.1u
M18r 2 3 0 1 NMOS L=0.13u W=24.5u
M18s 0 1 3 2 PMOS L=0.25u W=62.5u AD=28.13p AS=39.70p PD=233.1u PS=165.7u
M18t 3 0 2 1 PMOS L=0.35u W=41.2u
M18u 3 2 1 0 PMOS L=0.18u W=48.8u
M18v 2 0 1 3 PMOS L=0.50u W=17.0u
M18w 0 3 1 2 PMOS L=0.50u W=10.2u AD=16.67p AS=15.55p PD=30.0u PS=22.3u
C18x 3 1 2.2u
R18y 3 1 99
C18z 2 3 6.6u
R19a 3 1 87k
C19b 2 3 9.0u
R19c 0 3 443
R19d 1 0 30k
C19e 2 3 145p
R19f 1 0 45k
M19g 0 1 2 3 PMOS L=1.00u W=2.2u AD=3.08p AS=3.94p PD=6.0u PS=6.7u
M19h 2 3 0 1 NMOS L=0.13u W=21.6u
+ AD=25.05p AS=7.93p PD=45.8u PS=84.4u
C19i 0 3 81n
M19j 3 2 1 0 NMOS L=0.10u W=5.2u
+ AD=5.07p AS=4.12p PD=19.1u PS=18.8u
M19k 1 3 2 0 PMOS L=0.25u W=69.4u
M19l 2 3 0 1 PMOS L=0.35u W=67.3u
R19m 3 2 7.9M
M19n 3 2 1 0 NMOS L=0.70u W=1.3u AD=0.45p AS=2.16p PD=2.8u PS=4.2u
C19o 3 2 3.2m
C19p 0 2 2.0m
C19q 1 2 40n
M19r 1 0 2 3 PMOS L=0.10u W=7.9u
R19s 2 1 7.9M
M19t 0 3 2 1 NMOS L=0.10u W=30.3u AD=58.23p AS=38.61p PD=107.4u PS=111.1u
M19u 2 3 1 0 NMOS L=0.70u W=13.3u
C19v 0 1 47n
C19w 3 2 509p
R19x 3 1 89
M19y 1 0 2 3 PMOS L=0.18u W=93.1u
M19z 2 1 0 3 PMOS L=0.25u W=19.5u
R20a 3 2 455
C20b 1 0 1.4u
C20c 1 3 28p
M20d 3 2 0 1 NMOS L=0.25u W=6.0u
+ AD=6.68p AS=5.83p PD=22.5u PS=19.8u
C20e 2 1 78n
R20f 2 3 866
M20g 3 1 0 2 NMOS L=0.13u W=70.7u
R20h 3 0 0.2M
C20i 3 0 7.0u
C20j 0 2 657p
C20k 3 1 5.4m
M20l 0 3 2 1 PMOS L=0.18u W=95.0u AD=49.77p AS=181.97p PD=338.2u PS=272.9u
C20m 1 3 4.3m
C20n 2 3 6.9m
M20o 2 1 0 3 NMOS L=0.10u W=71.9u AD=82.42p AS=68.86p PD=178.3u PS=232.4u
M20p 0 3 1 2 NMOS L=0.50u W=93.2u
M20q 0 2 1 3 NMOS L=0.25u W=30.4u
R20r 0 1 5k
R20s 0 1 0.9M
C20t 2 3 5.1u
M20u 1 3 0 2 NMOS L=0.25u W=28.8u
+ AD=16.05p AS=19.57p PD=98.4u PS=89.8u
R20v 3 0 1.5M
R20w 0 1 81k
C20x 3 0 0.2m
C20y 3 0 4.7u
M20z 1 0 3 2 PMOS L=0.10u W=62.9u
+ AD=89.83p AS=103.44p PD=246.5u PS=224.5u
M21a 1 3 2 0 PMOS L=0.25u W=14.9u AD=26.07p AS=8.46p PD=45.1u PS=45.4u
M21b 0 3 2 1 NMOS L=0.13u W=53.7u
R21c 0 2 8.6M
M21d 0 1 2 3 NMOS L=0.25u W=8.6u
+ AD=14.07p AS=11.23p PD=17.7u PS=25.1u
C21e 3 0 6.1m
R21f 1 3 62k
C21g 2 3 510p
R21h 0 1 295
M21i 2 0 3 1 NMOS L=0.70u W=6.5u
+ AD=4.58p AS=12.37p PD=13.0u PS=24.7u
M21j 1 0 2 3 PMOS L=0.10u W=36.0u
C21k 1 0 739p
M21l 3 0 2 1 PMOS L=0.13u W=77.4u
M21m 0 1 2 3 PMOS L=0.50u W=44.4u
M21n 3 2 0 1 PMOS L=0.35u W=39.9u AD=61.86p AS=42.86p PD=125.4u PS=131.0u
C21o 0 2 5.9m
C21p 1 0 876p
C21q 2 1 745p
M21r 3 1 0 2 PMOS L=0.10u W=13.4u
+ AD=13.17p AS=10.90p PD=36.3u PS=38.8u
R21s 2 1 7.3M
M21t 3 0 1 2 NMOS L=0.10u W=72.9u
+ AD=26.46p AS=13.94p PD=281.8u PS=238.4u
R21u 3 1 401
M21v 1 0 3 2 NMOS L=0.18u W=57.9u
C21w 0 3 10n
C21x 1 0 46n
M21y 0 1 3 2 PMOS L=0.10u W=41.3u AD=35.90p AS=54.60p PD=107.2u PS=142.3u
M21z 1 2 0 3 NMOS L=0.13u W=58.5u
+ AD=113.09p AS=26.26p PD=132.7u PS=127.8u
R22a 0 1 41k
M22b 1 3 0 2 PMOS L=0.10u W=62.9u
C22c 1 2 162p
R22d 0 2 65k
R22e 1 0 75k
C22f 0 2 82n
M22g 2 3 0 1 PMOS L=0.70u W=43.3u
M22h 3 1 2 0 NMOS L=0.25u W=47.2u
+ AD=50.77p AS=90.65p PD=169.7u PS=129.2u
M22i 1 3 0 2 PMOS L=0.50u W=65.9u
M22j 3 0 1 2 NMOS L=0.13u W=78.0u
+ AD=17.17p AS=18.73p PD=306.4u PS=185.8u
R22k 0 1 82k
R22l 1 3 640
R22m 3 1 4.6M
C22n 3 1 8.4m
M22o 0 2 1 3 PMOS L=0.70u W=72.1u
+ AD=17.95p AS=43.50p PD=251.4u PS=281.3u
M22p 1 3 0 2 NMOS L=0.35u W=26.5u
R22q 2 3 800
M22r 2 0 1 3 NMOS L=0.25u W=47.3u
M22s 2 1 0 3 NMOS L=0.18u W=71.8u AD=83.96p AS=15.48p PD=270.1u PS=255.6u
M22t 2 0 3 1 NMOS L=0.70u W=95.7u AD=34.27p AS=25.77p PD=206.9u PS=332.0u
C22u 3 1 8.4m
C22v 1 0 3.2m
M22w 1 2 0 3 NMOS L=0.25u W=3.8u AD=2.53p AS=6.14p PD=14.8u PS=12.1u
M22x 3 1 0 2 PMOS L=0.18u W=7.1u
+ AD=12.61p AS=9.55p PD=20.8u PS=25.9u
M22y 3 1 2 0 NMOS L=0.25u W=78.9u
R22z 0 3 628
C23a 3 0 3.3u
M23b 2 3 1 0 PMOS L=0.13u W=42.8u
R23c 1 2 61k
C23d 1 2 384p
C23e 2 3 6.0u
M23f 3 1 2 0 NMOS L=0.13u W=4.8u AD=8.85p AS=9.01p PD=14.6u PS=10.9u
R23g 1 2 9.0M
C23h 2 1 352p
C23i 0 1 945p
R23j 2 1 891
C23k 1 2 1.4m
R23l 3 1 72
M23m 3 0 2 1 NMOS L=0.10u W=72.3u
+ AD=52.41p AS=138.11p PD=164.8u PS=158.6u
C23n 0 2 6.0m
R23o 0 1 887
C23p 0 1 1.0u
C23q 1 0 8.5u
R23r 2 0 2k
M23s 0 3 1 2 NMOS L=0.10u W=81.6u
+ AD=28.35p AS=105.62p PD=239.5u PS=325.5u
C23t 0 2 65n
R23u 1 0 5.0M
M23v 0 1 2 3 PMOS L=0.13u W=44.2u
C23w 0 3 5.9u
R23x 1 3 41k
M23y 0 3 1 2 NMOS L=0.35u W=84.6u AD=148.57p AS=15.61p PD=246.7u PS=326.7u
M23z 2 0 1 3 NMOS L=0.70u W=19.6u
C24a 0 3 18n
C24b 3 1 98n
C24c 3 2 2.5m
C24d 0 3 9.8m
C24e 2 0 0.9m
C24f 3 0 857p
C24g 1 2 4.8m
M24h 1 3 0 2 PMOS L=0.35u W=75.4u
C24i 2 1 91n
C24j 2 0 9.7m
C24k 2 3 282p
C24l 2 0 305p
M24m 3 1 2 0 NMOS L=1.00u W=36.5u
R24n 1 3 962
R24o 3 1 33k
M24p 0 2 1 3 PMOS L=0.70u W=24.0u
R24q 3 1 1.8M
R24r 1 0 294
M24s 1 0 3 2 PMOS L=1.00u W=10.0u
+ AD=10.06p AS=3.58p PD=23.4u PS=24.0u
C24t 2 1 39p
M24u 1 2 3 0 PMOS L=0.70u W=90.7u
C24v 3 1 0.6m
C24w 1 2 9.2u
C24x 1 2 509p
M24y 1 0 3 2 NMOS L=0.18u W=35.6u
+ AD=45.81p AS=65.61p PD=111.5u PS=136.7u
R24z 3 2 52k
R25a 2 0 5.6M
M25b 3 0 1 2 NMOS L=0.70u W=74.5u AD=70.26p AS=23.65p PD=236.7u PS=265.6u
R25c 0 2 6.9M
C25d 3 2 57n
C25e 3 2 29n
R25f 1 0 94k
C25g 0 2 8.2u
R25h 2 3 8.7M
M25i 3 2 0 1 NMOS L=0.18u W=43.3u AD=60.39p AS=30.42p PD=109.2u PS=137.6u
C25j 0 1 152p
M25k 2 3 0 1 PMOS L=0.18u W=93.3u
M25l 2 3 0 1 PMOS L=0.13u W=20.6u
R25m 1 2 898
M25n 0 2 3 1 NMOS L=0.18u W=71.3u
+ AD=129.85p AS=135.07p PD=275.5u PS=184.7u
C25o 2 0 5.8u
C25p 0 3 5.5m
M25q 2 1 0 3 PMOS L=0.13u W=68.5u
+ AD=101.01p AS=135.22p PD=195.5u PS=177.0u
M25r 1 3 0 2 PMOS L=0.35u W=11.4u
C25s 0 3 91n
R25t 2 1 108
R25u 0 1 93k
R25v 1 2 6.3M
C25w 1 0 985p
C25x 1 2 733p
C25y 0 2 8.5u
R25z 1 2 16k
R26a 3 2 39k
C26b 3 0 4.7m
C26c 2 1 9.3m
C26d 2 0 80n
R26e 1 3 81
M26f 0 1 2 3 PMOS L=0.18u W=77.0u
R26g 1 3 617
R26h 0 1 6.7M
R26i 3 0 5.9M
M26j 2 0 3 1 PMOS L=0.18u W=48.1u
M26k 2 0 3 1 NMOS L=0.13u W=28.4u
C26l 0 1 3.3m
R26m 0 2 97k
C26n 3 1 83n
C26o 2 0 3.8u
R26p 3 0 7.8M
R26q 2 3 687
M26r 0 3 1 2 PMOS L=0.10u W=95.9u
C26s 1 3 54n
M26t 2 3 0 1 NMOS L=0.13u W=84.9u AD=105.70p AS=103.39p PD=258.0u PS=178.0u
C26u 0 2 317p
C26v 0 2 4.4u
C26w 1 3 75n
R26x 1 3 97k
M26y 0 3 1 2 NMOS L=0.18u W=69.6u
R26z 2 3 963
M27a 3 1 0 2 NMOS L=0.35u W=28.2u AD=7.36p AS=48.52p PD=94.8u PS=100.4u
C27b 1 2 114p
R27c 0 1 8k
C27d 0 1 8.0u
M27e 3 1 0 2 PMOS L=0.13u W=85.8u
C27f 1 0 5.7m
M27g 0 1 3 2 NMOS L=0.70u W=30.8u
R27h 1 2 832
R27i 2 0 10k
M27j 0 1 3 2 NMOS L=0.13u W=70.0u
+ AD=95.81p AS=134.68p PD=223.5u PS=147.0u
C27k 2 1 5.8u
M27l 2 3 1 0 NMOS L=0.10u W=54.7u
+ AD=91.20p AS=61.57p PD=178.9u PS=194.3u
C27m 1 2 39n
R27n 1 2 5.1M
R27o 0 2 694
M27p 2 1 3 0 NMOS L=0.13u W=8.9u
R27q 1 2 48k
R27r 3 1 14k
R27s 0 3 894
M27t 0 3 1 2 NMOS L=0.13u W=77.2u
M27u 1 2 0 3 NMOS L=0.10u W=90.8u
+ AD=81.30p AS=80.72p PD=245.8u PS=359.3u
M27v 2 1 3 0 PMOS L=0.35u W=8.8u
+ AD=11.59p AS=17.52p PD=30.8u PS=23.2u
M27w 1 2 3 0 PMOS L=1.00u W=10.2u
R27x 2 0 60k
R27y 1 3 7.7M
R27z 0 3 6
C28a 0 3 9.0u
C28b 1 0 5.5m
C28c 0 1 6.7m
M28d 0 2 1 3 NMOS L=0.13u W=24.3u
+ AD=39.18p AS=12.62p PD=87.1u PS=92.2u
R28e 3 2 978
M28f 3 2 1 0 NMOS L=0.10u W=37.7u
M28g 1 2 3 0 NMOS L=0.25u W=19.0u
M28h 0 2 1 3 NMOS L=0.35u W=36.3u
+ AD=35.23p AS=54.78p PD=116.8u PS=109.1u
C28i 1 2 9.7u
R28j 1 2 2.1M
M28k 0 3 1 2 PMOS L=0.70u W=65.7u AD=12.49p AS=8.12p PD=200.6u PS=180.4u
R28l 3 0 168
C28m 3 1 862p
M28n 1 0 3 2 PMOS L=0.35u W=90.3u AD=150.88p AS=64.46p PD=329.7u PS=342.5u
M28o 1 3 2 0 NMOS L=0.10u W=57.2u
R28p 0 1 680
C28q 0 3 445p
R28r 1 2 1.0M
C28s 1 2 57n
M28t 1 3 2 0 PMOS L=0.70u W=57.0u
M28u 1 3 0 2 PMOS L=0.25u W=33.8u
M28v 0 2 3 1 NMOS L=0.25u W=57.8u
R28w 2 3 1000
C28x 3 0 77n
M28y 0 1 3 2 PMOS L=1.00u W=33.6u AD=43.83p AS=58.95p PD=83.5u PS=118.5u
R28z 3 2 64k
C29a 1 3 232p
C29b 0 3 16n
R29c 3 0 868
M29d 0 2 3 1 PMOS L=0.70u W=73.2u
M29e 2 0 3 1 PMOS L=0.35u W=7.4u AD=5.05p AS=11.04p PD=17.8u PS=21.1u
R29f 2 1 10k
M29g 2 3 1 0 PMOS L=0.70u W=66.2u AD=33.71p AS=33.78p PD=256.0u PS=199.9u
M29h 2 1 3 0 PMOS L=0.50u W=21.9u
R29i 2 0 5.3M
M29j 1 0 2 3 NMOS L=0.25u W=47.6u AD=75.72p AS=69.85p PD=145.7u PS=103.8u
C29k 2 0 25n
C29l 2 0 9.5u
R29m 0 3 507
R29n 3 0 17k
M29o 3 0 2 1 NMOS L=1.00u W=48.7u AD=31.72p AS=58.79p PD=171.6u PS=158.2u
R29p 0 1 89k
M29q 3 0 1 2 PMOS L=0.18u W=6.7u
R29r 1 3 67k
C29s 3 2 415p
C29t 0 2 760p
R29u 1 0 972
M29v 1 2 0 3 NMOS L=0.70u W=77.0u AD=114.47p AS=20.98p PD=240.2u PS=156.9u
C29w 3 1 524p
R29x 1 3 329
C29y 2 0 618p
R29z 2 3 186
C30a 0 2 7.1m
C30b 3 0 288p
R30c 3 2 545
M30d 1 2 0 3 NMOS L=0.35u W=69.0u
M30e 1 0 2 3 PMOS L=0.13u W=57.2u AD=112.69p AS=39.15p PD=199.8u PS=144.8u
M30f 1 3 2 0 NMOS L=0.18u W=88.6u
R30g 0 2 694
R30h 1 3 899
C30i 2 1 0.8m
R30j 1 3 1.2M
C30k 1 2 53n
C30l 2 3 3.2u
C30m 1 0 7.6u
R30n 2 3 14k
M30o 3 0 1 2 NMOS L=0.10u W=84.7u
R30p 3 0 72k
C30q 0 2 4.6u
R30r 0 3 83k
R30s 1 3 9.8M
C30t 1 2 97n
R30u 0 3 9.0M
R30v 0 3 615
C30w 1 2 0.3u
C30x 0 1 7.5m
C30y 2 1 8.4u
C30z 2 1 22n
C31a 2 0 7.0m
R31b 1 2 42k
M31c 0 3 1 2 NMOS L=0.25u W=46.4u
R31d 3 1 406
C31e 2 0 7.5m
C31f 2 1 92n
C31g 1 3 51n
M31h 1 2 3 0 PMOS L=1.00u W=19.8u
R31i 2 3 216
C31j 2 0 5.6u
R31k 3 0 819
R31l 2 1 47k
M31m 2 3 1 0 PMOS L=0.18u W=94.4u
+ AD=52.88p AS=103.22p PD=260.3u PS=232.5u
M31n 0 3 1 2 PMOS L=0.18u W=60.3u
C31o 2 0 6n
C31p 0 1 7.4u
C31q 3 0 8.7m
M31r 1 3 2 0 PMOS L=1.00u W=49.3u
M31s 3 1 2 0 NMOS L=0.25u W=57.3u
+ AD=32.19p AS=6.26p PD=144.6u PS=224.3u
C31t 1 2 687p
R31u 2 3 846
R31v 2 3 244
C31w 1 2 94n
C31x 0 2 66n
M31y 1 0 3 2 PMOS L=1.00u W=15.4u AD=3.81p AS=16.49p PD=31.1u PS=40.1u
C31z 0 1 16n
R32a 1 0 17k
R32b 3 2 27k
M32c 1 3 0 2 PMOS L=0.50u W=18.4u
C32d 3 1 350p
C32e 0 1 83n
R32f 0 2 678
R32g 1 2 666
C32h 1 3 2.2u
C32i 3 0 3.8u
C32j 2 3 374p
M32k 2 0 3 1 PMOS L=0.70u W=83.2u AD=12.77p AS=136.80p PD=196.7u PS=306.6u
C32l 3 0 8.8m
C32m 0 2 925p
R32n 1 2 24k
R32o 0 3 687
R32p 0 3 961
M32q 0 1 3 2 NMOS L=0.50u W=22.2u
C32r 3 1 617p
R32s 0 1 5.8M
R32t 1 3 10k
C32u 1 2 1.2u
M32v 3 2 0 1 PMOS L=0.25u W=10.1u
+ AD=19.97p AS=18.91p PD=23.0u PS=38.0u
R32w 1 3 948
C32x 1 0 509p
R32y 1 2 2.8M
R32z 3 2 231
C33a 0 1 3.4m
R33b 2 0 860
R33c 2 3 6.4M
M33d 2 3 1 0 PMOS L=0.18u W=86.1u AD=92.07p AS=94.73p PD=235.0u PS=200.4u
C33e 3 1 4.6u
R33f 2 0 235
R33g 1 0 98
C33h 1 2 92n
R33i 3 0 66k
M33j 0 3 1 2 NMOS L=0.50u W=76.5u
C33k 0 3 0.6m
M33l 1 3 2 0 NMOS L=0.35u W=66.8u
M33m 0 1 2 3 NMOS L=0.18u W=35.6u
M33n 1 0 2 3 NMOS L=0.70u W=65.7u AD=121.17p AS=88.00p PD=245.0u PS=165.3u
M33o 3 1 0 2 NMOS L=0.18u W=48.8u
+ AD=11.31p AS=65.24p PD=185.1u PS=175.7u
C33p 0 1 4.8u
R33q 2 3 75k
M33r 2 0 1 3 NMOS L=0.25u W=14.2u
+ AD=2.94p AS=6.41p PD=41.3u PS=29.7u
M33s 0 3 1 2 PMOS L=0.18u W=29.4u
+ AD=25.34p AS=28.16p PD=65.0u PS=72.4u
R33t 2 1 907
M33u 3 0 2 1 PMOS L=0.13u W=50.9u AD=86.88p AS=19.47p PD=195.1u PS=185.1u
R33v 0 2 74k
M33w 0 3 1 2 NMOS L=0.10u W=96.8u
R33x 0 1 530
M33y 2 1 0 3 PMOS L=0.10u W=98.8u
+ AD=79.81p AS=156.29p PD=294.1u PS=295.5u
C33z 0 1 2.1m
C34a 3 1 984p
M34b 2 0 3 1 PMOS L=0.18u W=1.8u
M34c 1 0 2 3 PMOS L=1.00u W=9.8u
+ AD=2.01p AS=17.80p PD=32.9u PS=26.5u
R34d 0 3 1.9M
R34e 0 3 2k
M34f 1 3 2 0 NMOS L=0.70u W=61.3u
+ AD=100.15p AS=23.12p PD=147.4u PS=152.9u
R34g 0 3 1.3M
R34h 1 2 4.9M
R34i 1 2 6.0M
M34j 1 0 3 2 NMOS L=0.18u W=2.4u
M34k 1 0 3 2 PMOS L=0.13u W=89.1u AD=64.63p AS=107.14p PD=202.9u PS=253.3u
R34l 0 1 302
C34m 3 0 89n
C34n 0 1 85n
C34o 1 3 673p
C34p 2 3 282p
R34q 2 3 144
M34r 1 2 3 0 NMOS L=0.35u W=19.5u
M34s 3 0 1 2 NMOS L=0.35u W=95.8u
+ AD=40.69p AS=141.47p PD=198.8u PS=301.9u
C34t 1 2 59n
M34u 1 3 0 2 PMOS L=0.18u W=2.9u
M34v 3 0 2 1 NMOS L=0.25u W=94.0u
R34w 1 3 68k
C34x 3 1 21n
R34y 3 1 60k
R34z 1 3 88k
R35a 2 1 81k
R35b 3 0 31k
M35c 0 1 2 3 PMOS L=0.35u W=32.3u AD=16.82p AS=24.07p PD=126.2u PS=121.9u
R35d 0 3 91k
R35e 2 1 28k
R35f 3 0 8k
M35g 3 2 0 1 PMOS L=0.25u W=14.6u
R35h 1 2 44k
R35i 1 3 864
R35j 0 2 17k
M35k 3 1 0 2 NMOS L=0.70u W=91.5u
+ AD=19.29p AS=59.75p PD=239.8u PS=314.5u
R35l 3 2 408
M35m 2 3 1 0 PMOS L=0.18u W=84.6u
R35n 2 3 51k
R35o 0 2 9.7M
R35p 0 3 2.3M
C35q 0 1 84n
M35r 1 0 3 2 PMOS L=0.18u W=68.6u
R35s 0 3 7.7M
C35t 1 3 3.0m
R35u 2 0 9.9M
C35v 2 3 64n
M35w 3 0 2 1 NMOS L=0.13u W=2.8u
M35x 2 0 3 1 PMOS L=0.18u W=89.3u
C35y 3 2 5.7u
M35z 3 1 0 2 NMOS L=0.18u W=12.0u AD=17.95p AS=1.47p PD=24.3u PS=45.0u
R36a 3 0 1k
M36b 0 2 3 1 PMOS L=0.70u W=7.8u
M36c 3 1 2 0 NMOS L=0.10u W=59.3u
M36d 1 3 0 2 PMOS L=1.00u W=93.0u
C36e 0 1 188p
C36f 2 1 6.6u
M36g 2 0 1 3 NMOS L=1.00u W=70.9u
R36h 1 0 9.6M
R36i 3 1 226
R36j 2 3 99k
R36k 1 0 870
M36l 2 3 0 1 NMOS L=0.10u W=12.8u
C36m 1 0 7.9u
M36n 3 1 2 0 PMOS L=1.00u W=61.9u
R36o 1 2 6.4M
M36p 1 3 2 0 PMOS L=0.50u W=94.3u AD=160.85p AS=107.66p PD=263.1u PS=279.9u
C36q 3 0 1.5m
R36r 2 3 42k
C36s 0 3 182p
C36t 3 0 6.7m
M36u 2 1 0 3 PMOS L=0.35u W=86.7u AD=23.72p AS=31.76p PD=306.6u PS=227.8u
R36v 0 1 983
R36w 2 3 65k
R36x 2 1 787
C36y 0 3 892p
C36z 0 3 99n
R37a 3 0 0.6M
M37b 0 3 2 1 NMOS L=0.25u W=48.9u AD=81.42p AS=83.25p PD=126.3u PS=144.1u
C37c 3 1 503p
R37d 2 3 9.8M
R37e 0 3 80k
R37f 2 3 93
R37g 2 0 82k
C37h 3 0 46n
R37i 1 2 9.5M
R37j 0 1 294
R37k 0 3 0.8M
R37l 3 1 3.9M
C37m 0 1 787p
M37n 2 0 3 1 PMOS L=0.35u W=4.1u
C37o 0 3 54n
C37p 1 0 3.2m
M37q 1 2 0 3 NMOS L=0.70u W=30.0u
+ AD=49.37p AS=54.59p PD=62.9u PS=73.2u
R37r 1 3 424
C37s 2 3 460p
C37t 0 2 1.9u
M37u 2 1 3 0 PMOS L=0.35u W=4.3u
R37v 1 0 0.1M
M37w 1 2 0 3 NMOS L=0.25u W=77.2u
M37x 0 3 1 2 NMOS L=0.50u W=10.1u
+ AD=7.87p AS=3.63p PD=25.1u PS=26.6u
M37y 0 1 2 3 NMOS L=0.70u W=32.3u
C37z 0 2 5.9m
R38a 1 2 929
R38b 3 2 270
C38c 0 2 0.5m
C38d 1 2 84n
C38e 3 2 5.7u
R38f 0 1 5.5M
M38g 0 3 2 1 NMOS L=0.50u W=24.0u
+ AD=27.68p AS=19.02p PD=79.8u PS=63.7u
R38h 1 0 66
C38i 0 1 4.7u
C38j 0 3 1.4u
C38k 3 2 2.4u
C38l 0 2 0.7u
R38m 2 0 0.2M
C38n 3 1 723p
M38o 1 0 3 2 PMOS L=0.25u W=48.8u AD=42.56p AS=8.08p PD=158.8u PS=171.7u
M38p 2 1 0 3 PMOS L=0.25u W=25.1u
R38q 3 2 527
C38r 2 1 8.0u
M38s 2 0 1 3 NMOS L=0.13u W=90.1u
R38t 2 3 31k
C38u 1 2 7.0u
R38v 2 3 38
M38w 2 1 0 3 NMOS L=0.70u W=80.5u
+ AD=14.97p AS=38.47p PD=311.6u PS=252.9u
C38x 3 2 7n
M38y 0 1 3 2 NMOS L=0.13u W=63.7u
C38z 1 0 8.9u
R39a 1 0 1.7M
R39b 2 3 8k
C39c 0 2 9.8u
R39d 3 0 754
C39e 2 3 278p
R39f 0 2 938
C39g 3 2 67p
M39h 3 0 2 1 PMOS L=0.13u W=94.6u
+ AD=16.88p AS=151.46p PD=216.7u PS=368.5u
M39i 2 3 0 1 PMOS L=0.13u W=37.9u
R39j 0 3 3.9M
C39k 2 1 64n
M39l 3 2 1 0 NMOS L=0.70u W=5.4u
* SPICE Model Definitions
.MODEL NMOS NMOS (LEVEL=1 VTO=0.7 KP=110E-6 LAMBDA=0.04
+            TOX=9E-9 NSUB=1E17 GAMMA=0.4 PHI=0.7)
.MODEL PMOS PMOS (LEVEL=1 VTO=-0.7 KP=50E-6 LAMBDA=0.05
+            TOX=9E-9 NSUB=1E17 GAMMA=0.5 PHI=0.8)
.OP
.END
